M7 (net42 VIN2 IB2 VSS) nmos4
M6 (net48 VIN1 IB2 VSS) nmos4
M5 (VOUT1 VIN2 net44 VSS) nmos4
M4 (VOUT2 VIN1 net44 VSS) nmos4
M3 (VOUT2 VIN2 net46 VSS) nmos4
M2 (VOUT1 VIN1 net46 VSS) nmos4
M1 (net46 net48 IB1 VSS) nmos4
M0 (net44 net42 IB1 VSS) nmos4
C3 (VOUT2 VSS) capacitor
C2 (VSS VOUT1) capacitor
L1 (VDD VOUT2) inductor
L0 (VDD VOUT1) inductor
R1 (VDD net48) resistor
R0 (VDD net42) resistor
