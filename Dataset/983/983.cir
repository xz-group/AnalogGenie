M16 (VOUT1 net98 VDD VDD) pmos4
M15 (VSS net97 net98 VDD) pmos4
M14 (net98 net89 VDD VDD) pmos4
M0 (net113 net89 VDD VDD) pmos4
M5 (net89 net90 net113 VDD) pmos4
M4 (net97 net90 net112 VDD) pmos4
M3 (net93 net95 VDD VDD) pmos4
M2 (net95 net95 VDD VDD) pmos4
M1 (net112 net89 VDD VDD) pmos4
M17 (VOUT1 VB1 VSS VSS) nmos4
M13 (net91 VB1 VSS VSS) nmos4
M12 (net110 VIN2 net91 VSS) nmos4
M11 (net95 VIN2 net91 VSS) nmos4
M10 (net95 VIN1 net91 VSS) nmos4
M9 (net111 VIN1 net91 VSS) nmos4
M8 (net90 net93 net111 VSS) nmos4
M7 (net93 net93 net91 VSS) nmos4
M6 (net97 net93 net110 VSS) nmos4
R0 (net89 net90) resistor
C0 (net97 VOUT1) capacitor
