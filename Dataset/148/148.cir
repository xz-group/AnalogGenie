R0 (VDD net30) resistor
M1 (net26 net30 VSS VSS) nmos4
M0 (net30 net30 VSS VSS) nmos4
M3 (net30 net26 VDD VDD) pmos4
M2 (net26 net26 VDD VDD) pmos4
