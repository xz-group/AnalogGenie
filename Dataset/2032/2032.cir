MM6 (VOUT1 net1005 VSS VSS) nmos4
MM3 (net011 VIN1 net16 VSS) nmos4
MM0 (net07 VIN2 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM1 (net011 net07 VDD VDD) pmos4
MM2 (net07 net07 VDD VDD) pmos4
MM5 (VOUT1 net011 VDD VDD) pmos4
CC0 (VOUT1 net011) capacitor
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 VDD VDD) pmos4
