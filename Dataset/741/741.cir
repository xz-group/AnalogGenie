M2 (net38 net38 VDD VDD) pmos4
M1 (net10 net10 VDD VDD) pmos4
M3 (VOUT2 net38 VDD VDD) pmos4
M0 (VOUT1 net10 VDD VDD) pmos4
M11 (net24 VDD VSS VSS) nmos4
M10 (net16 VTRACK1 VSS VSS) nmos4
M4 (net38 VIN2 IB1 VSS) nmos4
M5 (net10 VIN1 IB1 VSS) nmos4
M6 (VOUT2 VOUT2 net16 VSS) nmos4
M7 (VOUT1 VOUT1 net16 VSS) nmos4
M8 (VOUT2 VOUT1 net24 VSS) nmos4
M9 (VOUT1 VOUT2 net24 VSS) nmos4
