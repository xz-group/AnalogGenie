M5 (net018 net010 VSS VSS) nmos4
M2 (VOUT1 VB2 net018 VSS) nmos4
M6 (VOUT2 VB2 net017 VSS) nmos4
M3 (net017 net010 VSS VSS) nmos4
M7 (VOUT2 VB1 VIN2 VDD) pmos4
M8 (VOUT1 VB1 VIN1 VDD) pmos4
R3 (net010 VOUT2) resistor
R2 (VOUT1 net010) resistor
R1 (VDD VIN2) resistor
R0 (VDD VIN1) resistor
C1 (VOUT2 VSS) capacitor
C0 (VOUT1 VSS) capacitor
