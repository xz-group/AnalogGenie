L1 (net02 IB1) inductor
L2 (VDD net011) inductor
L0 (VDD net013) inductor
M0 (net013 net011 net02 VSS) nmos4
M3 (net011 net013 net02 VSS) nmos4
C1 (IB1 VSS) capacitor
C0 (net02 VSS) capacitor
