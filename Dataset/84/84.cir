M2 (VOUT2 VIN2 net08 VSS) nmos4
M0 (VOUT1 VIN1 net08 VSS) nmos4
M1 (net08 VB1 VSS VSS) nmos4
M4 (VOUT2 VB2 net013 net013) pmos4
M3 (VOUT1 VB2 net014 net014) pmos4
R1 (VDD net013) resistor
R0 (VDD net014) resistor
