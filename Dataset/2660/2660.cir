MM10 (net27 net12 VSS VSS) nmos4
MM9 (net21 net12 VSS VSS) nmos4
MM8 (net12 net1003 net27 VSS) nmos4
MM7 (VOUT1 net1003 net21 VSS) nmos4
MM3 (net32 VSS net10 VSS) nmos4
MM0 (net26 net12 net10 VSS) nmos4
MM4 (net10 VB2 VSS VSS) nmos4
MM6 (net12 VB3 net26 VDD) pmos4
MM5 (VOUT1 VB3 net32 VDD) pmos4
MM1 (net32 VB1 VDD VDD) pmos4
MM2 (net26 VB1 VDD VDD) pmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR0 (VB4 VSS) resistor
MM2 (net1006 net12 VB4 VSS) nmos4
MM0 (net12 VB4 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (net12 net1006 VDD VDD) pmos4
M12 (VIN1 VCLK1 net11 VSS) nmos4
M13 (net11 VCLK2 net12 VSS) nmos4
C1 (net12 VOUT1) capacitor
C0 (net11 VSS) capacitor
