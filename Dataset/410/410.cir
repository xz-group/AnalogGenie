M5 (VDD VOUT2 IB3 VSS) nmos4
M4 (VDD VOUT1 IB2 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
M1 (VOUT2 VIN2 IB1 VSS) nmos4
M3 (VOUT2 IB3 VDD VDD) pmos4
M2 (VOUT1 IB2 VDD VDD) pmos4
