M8 (net13 IB1 VSS VSS) nmos4
M7 (net9 IB1 VSS VSS) nmos4
M6 (IB1 IB1 VSS VSS) nmos4
M4 (net11 net15 net9 VSS) nmos4
M5 (net10 VB1 net9 VSS) nmos4
M3 (net10 net10 VDD VDD) pmos4
M2 (VOUT1 net13 VDD VDD) pmos4
M1 (net13 net11 VDD VDD) pmos4
M0 (net11 net10 VDD VDD) pmos4
R2 (net24 VSS) resistor
R1 (net15 VSS) resistor
R0 (VOUT1 net15) resistor
C2 (net11 net13) capacitor
C0 (VOUT1 net24) capacitor
