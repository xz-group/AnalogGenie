M1 (net9 VIN2 IB1 VSS) nmos4
M0 (net10 VIN1 IB1 VSS) nmos4
M4 (net9 VB1 VDD VSS) pmos4
M2 (net10 VB1 VDD VSS) pmos4
