M1 (VOUT2 VIN2 VSS VSS) nmos4
M1 (VOUT1 VIN1 VSS VSS) nmos4
R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
