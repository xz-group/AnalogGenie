M3 (VOUT2 VOUT2 VDD VDD) pmos4
M2 (VOUT1 VOUT2 VDD VDD) pmos4
M1 (VOUT2 VOUT1 VDD VDD) pmos4
M0 (VOUT1 VOUT1 VDD VDD) pmos4
M7 (IB1 IB1 VSS VSS) nmos4
M6 (net20 IB1 VSS VSS) nmos4
M5 (VOUT2 VIN2 net20 VSS) nmos4
M4 (VOUT1 VIN1 net20 VSS) nmos4
