M19 (net8 net8 net26 VDD) pmos4
M18 (net26 net8 net19 VDD) pmos4
M17 (net49 net26 net57 VDD) pmos4
M16 (net16 net26 net59 VDD) pmos4
M15 (net19 net26 net60 VDD) pmos4
M14 (net57 net19 VDD VDD) pmos4
M13 (net59 net19 VDD VDD) pmos4
M12 (net60 net19 VDD VDD) pmos4
M3 (VOUT2 net26 net54 VDD) pmos4
M2 (VOUT1 net26 net52 VDD) pmos4
M1 (net54 net19 VDD VDD) pmos4
M0 (net52 net19 VDD VDD) pmos4
M24 (net49 net49 VSS VSS) nmos4
M23 (net17 net35 net58 VSS) nmos4
M22 (net35 net16 net17 VSS) nmos4
M21 (net58 net17 VSS VSS) nmos4
M20 (net16 net16 net35 VSS) nmos4
M11 (net53 net17 VSS VSS) nmos4
M10 (net51 VCM1 VSS VSS) nmos4
M9 (net61 net17 VSS VSS) nmos4
M8 (net62 net17 VSS VSS) nmos4
M7 (net54 VIN2 net53 VSS) nmos4
M6 (net52 VIN1 net51 VSS) nmos4
M5 (VOUT2 net35 net61 VSS) nmos4
M4 (VOUT1 net35 net62 VSS) nmos4
R0 (net8 VSS) resistor
