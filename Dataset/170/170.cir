M1 (VDD VOUT1 IB1 VSS) nmos4
M0 (VOUT1 IB1 VSS VSS) nmos4
R1 (VDD VOUT1) resistor
R0 (VIN1 IB1) resistor
