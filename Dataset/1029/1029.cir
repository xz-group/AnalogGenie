M3 (net16 VCM1 VDD VDD) pmos4
M2 (net16 VCM1 VDD VDD) pmos4
M1 (net9 VOUT2 VDD VDD) pmos4
M0 (net9 VOUT1 VDD VDD) pmos4
M5 (net16 net9 VSS VSS) nmos4
M4 (net9 net9 VSS VSS) nmos4
