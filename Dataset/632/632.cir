M9 (VOUT1 net12 VSS VSS) nmos4
M8 (net12 IB1 VSS VSS) nmos4
M7 (IB1 IB1 VSS VSS) nmos4
M6 (net9 IB1 VSS VSS) nmos4
M5 (net10 VB1 net9 net22) nmos4
M4 (net8 VIN1 net9 net22) nmos4
M3 (VOUT1 net12 VDD VDD) pmos4
M2 (net12 net10 VDD VDD) pmos4
M1 (net8 net8 VDD VDD) pmos4
M0 (net10 net8 VDD VDD) pmos4
