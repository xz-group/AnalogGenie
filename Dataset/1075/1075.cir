M18 (VOUT4 VIN2 VSS VSS) nmos4
M17 (VOUT4 VCM1 VSS VSS) nmos4
M16 (VOUT3 VCM1 VSS VSS) nmos4
M15 (VOUT3 VIN1 VSS VSS) nmos4
M5 (net55 VCLK1 VSS VSS) nmos4
M4 (net36 VCLK1 VSS VSS) nmos4
M9 (VOUT1 VCLK1 VSS VSS) nmos4
M8 (VOUT2 VCLK1 VSS VSS) nmos4
M7 (VOUT2 VOUT1 VSS VSS) nmos4
M6 (VOUT1 VOUT2 VSS VSS) nmos4
M14 (VOUT4 VIN2 VDD VDD) pmos4
M13 (VOUT4 VCM1 VDD VDD) pmos4
M12 (VOUT3 VCM1 VDD VDD) pmos4
M11 (VOUT3 VIN1 VDD VDD) pmos4
M10 (net81 VCLK1 VDD VDD) pmos4
M1 (net55 VOUT4 net81 net81) pmos4
M0 (net36 VOUT3 net81 net81) pmos4
M3 (VOUT2 VOUT1 net55 net81) pmos4
M2 (VOUT1 VOUT2 net36 net81) pmos4
