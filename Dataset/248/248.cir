M1 (VOUT1 net11 IB1 VSS) nmos4
M0 (net8 VIN1 IB1 VSS) nmos4
M3 (net8 net8 VDD VDD) pmos4
M2 (VOUT1 net8 VDD VDD) pmos4
R1 (net11 VSS) resistor
R0 (VOUT1 net11) resistor
