M1 (net5 VOUT1 VSS VSS) nmos4
M0 (VDD net5 VOUT1 VSS) nmos4
R1 (VOUT1 VSS) resistor
R0 (VIN1 net5) resistor
C0 (VOUT1 VSS) capacitor
