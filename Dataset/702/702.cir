R2 (VDD VOUT1) resistor
R1 (IIN1 VOUT1) resistor
R0 (IIN1 VSS) resistor
M1 (VOUT1 IB2 VSS VSS) nmos4
M2 (IB2 IB1 VSS VSS) nmos4
M0 (IB1 IIN1 VSS VSS) nmos4
C0 (VOUT1 VSS) capacitor
