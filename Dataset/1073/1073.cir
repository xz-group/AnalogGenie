M6 (VOUT2 net43 VDD VDD) pmos4
M4 (net43 VCLK1 VDD VDD) pmos4
M3 (net43 net15 VDD VDD) pmos4
M2 (net15 net43 VDD VDD) pmos4
M1 (net15 VCLK1 VDD VDD) pmos4
M0 (VOUT1 net15 VDD VDD) pmos4
M17 (net35 VCLK1 VSS VSS) nmos4
M16 (net41 VIN4 net35 VSS) nmos4
M15 (net20 VIN3 net35 VSS) nmos4
M14 (net14 VCLK1 VSS VSS) nmos4
M13 (net41 VIN2 net14 VSS) nmos4
M12 (net20 VIN1 net14 VSS) nmos4
M11 (VDD VCLK1 net41 VSS) nmos4
M10 (VDD VCLK1 net20 VSS) nmos4
M9 (VOUT2 net43 VSS VSS) nmos4
M8 (net43 net15 net41 VSS) nmos4
M7 (net15 net43 net20 VSS) nmos4
M5 (VOUT1 net15 VSS VSS) nmos4
