M2 (net3 VB1 VDD VDD) pmos4
M0 (net3 net3 VDD VDD) pmos4
M1 (VOUT1 VB1 VIN1 VSS) nmos4
R0 (net3 VOUT1) resistor
