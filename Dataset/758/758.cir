M2 (net15 net12 VDD VDD) pmos4
M1 (IB3 IB3 VDD VDD) pmos4
M0 (net12 IB3 VDD VDD) pmos4
Q6 (VDD net15 VOUT1 0) npn
Q5 (net32 IB2 net14 0) npn
Q4 (net15 VB1 net32 0) npn
Q3 (net31 IB1 net14 0) npn
Q2 (net12 VB1 net31 0) npn
Q1 (VDD net9 IB2 0) npn
Q0 (VDD net8 IB1 0) npn
C2 (net9 VOUT1) capacitor
C1 (net8 VSS) capacitor
C0 (net12 net33) capacitor
R2 (VOUT1 VSS) resistor
R1 (net14 VSS) resistor
R0 (net33 net15) resistor
M5 (net9 VCLK1 VOUT1 VSS) nmos4
M3 (net8 VCLK1 VIN1 VSS) nmos4
