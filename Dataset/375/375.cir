M1 (VOUT1 VB1 VDD VDD) pmos4
M0 (net02 VB1 VDD VDD) pmos4
Q1 (VSS net02 VOUT1 0) pnp
Q0 (VSS VSS net02 0) pnp
