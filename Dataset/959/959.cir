M3 (net11 VB2 net21 VDD) pmos4
M2 (VSS VIN1 net22 VDD) pmos4
M1 (VOUT1 net14 VDD VDD) pmos4
M0 (net14 net14 VDD VDD) pmos4
M7 (VOUT1 net11 VSS VSS) nmos4
M6 (net11 net11 VSS VSS) nmos4
M5 (net14 VB1 net22 VSS) nmos4
M4 (VDD VIN1 net21 VSS) nmos4
C0 (VOUT1 VSS) capacitor
R0 (VOUT1 VSS) resistor
