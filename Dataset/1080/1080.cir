M27 (net177 VCLK1 VDD VDD) pmos4
M26 (net175 VCLK1 VDD VDD) pmos4
M21 (net173 VIN2 net169 VDD) pmos4
M20 (net165 VIN1 net169 VDD) pmos4
M19 (net169 VCLK2 VDD VDD) pmos4
M0 (net166 VCLK1 VDD VDD) pmos4
M16 (net187 VCLK1 VDD VDD) pmos4
M15 (net193 VCLK1 VDD VDD) pmos4
M12 (VOUT2 VCLK1 VDD VDD) pmos4
M11 (VOUT2 VOUT1 VDD VDD) pmos4
M10 (VOUT1 VOUT2 VDD VDD) pmos4
M9 (VOUT1 VCLK1 VDD VDD) pmos4
M6 (net178 net174 VDD VDD) pmos4
M5 (net190 net166 VDD VDD) pmos4
M1 (net174 VCLK1 VDD VDD) pmos4
M31 (net197 net173 VSS VSS) nmos4
M30 (VOUT2 net175 net197 VSS) nmos4
M29 (net198 net165 VSS VSS) nmos4
M28 (VOUT1 net177 net198 VSS) nmos4
M25 (net177 net173 VSS VSS) nmos4
M24 (net175 net165 VSS VSS) nmos4
M23 (net173 VCLK2 VSS VSS) nmos4
M22 (net165 VCLK2 VSS VSS) nmos4
M18 (net187 net190 VSS VSS) nmos4
M17 (net193 net178 VSS VSS) nmos4
M14 (VOUT2 VOUT1 net187 VSS) nmos4
M13 (VOUT1 VOUT2 net193 VSS) nmos4
M8 (net178 VCLK2 VSS VSS) nmos4
M7 (net190 VCLK2 VSS VSS) nmos4
M4 (net171 VCLK1 VSS VSS) nmos4
M2 (net166 VIN1 net171 VSS) nmos4
M3 (net174 VIN2 net171 VSS) nmos4
