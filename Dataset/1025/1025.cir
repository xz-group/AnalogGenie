M7 (net29 net39 net37 VDD) pmos4
M6 (net18 net39 net35 VDD) pmos4
M5 (net30 net39 net45 VDD) pmos4
M4 (VOUT1 net30 VDD VDD) pmos4
M3 (net45 net30 VDD VDD) pmos4
M2 (net37 net34 VDD VDD) pmos4
M1 (net35 net34 VDD VDD) pmos4
M0 (net7 net34 VDD VDD) pmos4
R0 (net30 net39) resistor
M15 (VOUT1 net29 VSS VSS) nmos4
M14 (net39 net7 VSS VSS) nmos4
M13 (net14 net7 VSS VSS) nmos4
M12 (net7 net7 VSS VSS) nmos4
M11 (net29 net18 VSS VSS) nmos4
M10 (net18 net18 VSS VSS) nmos4
M9 (net37 VIN1 net14 VSS) nmos4
M8 (net35 VIN2 net14 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net29) capacitor
