M3 (net20 net20 VDD VDD) pmos4
M9 (VOUT1 net39 VDD VDD) pmos4
M6 (net39 net19 net36 VDD) pmos4
M5 (net31 net45 net36 VDD) pmos4
M4 (net45 net20 VDD VDD) pmos4
M2 (net36 net31 VDD VDD) pmos4
M1 (net19 net12 VDD VDD) pmos4
M0 (net12 net12 VDD VDD) pmos4
M23 (VOUT1 net39 VSS VSS) nmos4
M22 (net39 net19 net35 VSS) nmos4
M21 (net31 net45 net35 VSS) nmos4
M20 (IB1 IB1 VSS VSS) nmos4
M19 (net15 IB1 VSS VSS) nmos4
M18 (net22 net22 VSS VSS) nmos4
M17 (net45 net45 net22 VSS) nmos4
M16 (net45 net19 net22 VSS) nmos4
M15 (net19 net45 net22 VSS) nmos4
M14 (net19 net19 net22 VSS) nmos4
M13 (net35 net31 VSS VSS) nmos4
M12 (net20 VIN2 net15 VSS) nmos4
M11 (net12 VIN1 net15 VSS) nmos4
