M29 (net63 net63 VDD VDD) pmos4
M28 (net90 net44 VDD VDD) pmos4
M27 (net44 net28 VDD VDD) pmos4
M26 (net28 net28 VDD VDD) pmos4
M20 (net72 net61 VDD VDD) pmos4
M19 (net61 net61 VDD VDD) pmos4
M18 (net29 net29 VDD VDD) pmos4
M17 (net82 net29 VDD VDD) pmos4
M12 (net66 VCLK2 net66 VDD) pmos4
M11 (net14 VCLK2 net14 VDD) pmos4
M8 (net66 VCLK1 net57 VDD) pmos4
M7 (net14 VCLK1 net79 VDD) pmos4
M6 (VOUT1 VREF2 VDD VDD) pmos4
M5 (net75 net57 VDD VDD) pmos4
M4 (net57 net57 VDD VDD) pmos4
M3 (net79 net57 VDD VDD) pmos4
M2 (net57 net79 VDD VDD) pmos4
M1 (net79 net79 VDD VDD) pmos4
M0 (net11 net79 VDD VDD) pmos4
M35 (net69 net90 VSS VSS) nmos4
M34 (net90 net90 VSS VSS) nmos4
M33 (net27 VB1 VSS VSS) nmos4
M32 (net63 net63 net69 net69) nmos4
M31 (net44 net63 net27 net27) nmos4
M30 (net28 VREF1 net27 net27) nmos4
M25 (net35 VB1 VSS VSS) nmos4
M24 (net43 VB1 VSS VSS) nmos4
M23 (net61 VIN2 net35 net43) nmos4
M22 (net29 VIN1 net35 net43) nmos4
M21 (VDD VREF2 net43 net43) nmos4
M16 (VOUT1 net75 VSS VSS) nmos4
M15 (net75 net11 VSS VSS) nmos4
M14 (net42 net90 VSS VSS) nmos4
M13 (net11 net11 VSS VSS) nmos4
M10 (net57 net66 net42 net94) nmos4
M9 (net79 net14 net42 net94) nmos4
R1 (net72 VSS) resistor
R0 (net82 VSS) resistor
C2 (VDD net44) capacitor
C1 (net66 net72) capacitor
C0 (net14 net82) capacitor
