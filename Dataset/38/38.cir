M1 (VOUT1 VB2 net10 VDD) pmos4
M0 (net10 VB3 VDD VDD) pmos4
M3 (net9 VIN1 VSS VSS) nmos4
M2 (VOUT1 VB1 net9 VSS) nmos4
