R1 (VDD IOUT1) resistor
R0 (VDD IOUT2) resistor
Q3 (VDD VSS IB2 0) npn
Q2 (IOUT1 IB2 IB1 0) npn
Q1 (VDD VSS IB3 0) npn
Q0 (IOUT2 IB3 IB1 0) npn
