M4 (net014 net012 net017 VSS) nmos4
M1 (net012 net012 VSS VSS) nmos4
R0 (net017 VSS) resistor
M13 (net014 net014 VDD VDD) pmos4
M3 (net012 net014 VDD VDD) pmos4
