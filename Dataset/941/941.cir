R1 (VDD net48) resistor
R0 (net56 VSS) resistor
M6 (net54 net54 net57 VSS) nmos4
M4 (VDD net48 net54 VSS) nmos4
M3 (net51 net54 net56 VSS) nmos4
M7 (net48 net48 VSS VSS) nmos4
M2 (IOUT1 net51 VDD VDD) pmos4
M1 (net51 net51 VDD VDD) pmos4
M0 (net54 net51 VDD VDD) pmos4
Q0 (VSS VSS net57 0) pnp
