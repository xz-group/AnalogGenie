M3 (net19 VIN1 VDD VDD) pmos4
M2 (VSS VB2 net8 VDD) pmos4
M1 (VIN1 VB1 net8 VDD) pmos4
M0 (net8 VB3 VDD VDD) pmos4
M4 (net19 VIN1 VSS VSS) nmos4
