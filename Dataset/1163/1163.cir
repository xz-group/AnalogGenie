M3 (net12 net7 VDD VDD) pmos4
M0 (net16 net8 VDD VDD) pmos4
L7 (net10 net7) inductor
L6 (net12 net10) inductor
L5 (net6 net7) inductor
L4 (net15 net6) inductor
L3 (net10 net8) inductor
L2 (net13 net10) inductor
L1 (net6 net8) inductor
L0 (net16 net6) inductor
C7 (net7 VSS) capacitor
C6 (net12 VSS) capacitor
C5 (net7 VSS) capacitor
C4 (net15 VSS) capacitor
C3 (net8 VSS) capacitor
C2 (net13 VSS) capacitor
C1 (net8 VSS) capacitor
C0 (net16 VSS) capacitor
M2 (net15 net7 VSS VSS) nmos4
M1 (net13 net8 VSS VSS) nmos4
