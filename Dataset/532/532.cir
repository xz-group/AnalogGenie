M2 (net022 net023 VDD VDD) pmos4
M5 (net023 net022 VDD VDD) pmos4
M0 (net023 net022 IB1 VSS) nmos4
M3 (net022 net023 IB1 VSS) nmos4
M1 (VCONT1 net022 VCONT1 VSS) nmos4
M4 (VCONT1 net023 VCONT1 VSS) nmos4
L0 (net023 net022) inductor
