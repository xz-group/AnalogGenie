M19 (net108 VCLK1 VSS VSS) nmos4
M18 (net106 VCLK2 VSS VSS) nmos4
M17 (net108 VCLK2 net109 VSS) nmos4
M16 (VIN1 VCLK1 net106 VSS) nmos4
M15 (net114 VCLK2 VSS VSS) nmos4
M14 (net111 VCLK2 VSS VSS) nmos4
M13 (net114 VCLK1 VOUT1 VSS) nmos4
M12 (net109 VCLK1 net111 VSS) nmos4
M9 (net118 net109 IB1 VSS) nmos4
M8 (net119 VSS IB1 VSS) nmos4
M5 (VOUT1 VB2 net120 VSS) nmos4
M4 (net121 VB2 net117 VSS) nmos4
M7 (net120 net121 VSS VSS) nmos4
M6 (net117 net121 VSS VSS) nmos4
C5 (net108 net106) capacitor
C2 (net109 VIN1) capacitor
C1 (net111 net114) capacitor
C4 (net109 VOUT1) capacitor
M1 (net118 VB3 VDD VDD) pmos4
M0 (net119 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net118 VDD) pmos4
M2 (net121 VB1 net119 VDD) pmos4
