M1 (net16 net12 VSS VSS) nmos4
M0 (net12 VIN1 VSS VSS) nmos4
R1 (VOUT1 VSS) resistor
R0 (VB1 VIN1) resistor
L7 (VSS VOUT1) inductor
L6 (net19 net20) inductor
L5 (net18 net19) inductor
L4 (net16 net18) inductor
L3 (net16 VDD) inductor
L2 (net12 VB2) inductor
L1 (VB2 net10) inductor
L0 (net10 net12) inductor
C6 (VOUT1 VSS) capacitor
C5 (VOUT1 net20) capacitor
C4 (net20 VSS) capacitor
C3 (net19 VSS) capacitor
C2 (net18 VSS) capacitor
C1 (VB2 net10) capacitor
C0 (net10 net12) capacitor
M2 (net16 VCONT1 VDD VDD) pmos4
