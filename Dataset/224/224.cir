R1 (net6 VSS) resistor
R0 (net3 VSS) resistor
R3 (net3 net6) resistor
M10 (IB2 VIN2 net6 VSS) nmos4
M9 (IB1 VIN1 net3 VSS) nmos4
M1 (net6 IB2 VDD VDD) pmos4
M0 (net3 IB1 VDD VDD) pmos4
