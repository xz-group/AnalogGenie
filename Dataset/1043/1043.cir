M7 (VOUT2 VIN5 net24 VSS) nmos4
M6 (VOUT1 VIN1 net24 VSS) nmos4
M5 (VOUT1 VIN4 net22 VSS) nmos4
M4 (VOUT2 VIN1 net22 VSS) nmos4
M3 (VOUT1 VIN3 net18 VSS) nmos4
M2 (VOUT2 VIN1 net18 VSS) nmos4
M1 (VOUT1 VIN2 net11 VSS) nmos4
M0 (VOUT2 VIN1 net11 VSS) nmos4
R5 (net24 VSS) resistor
R4 (net22 VSS) resistor
R3 (net18 VSS) resistor
R2 (net11 VSS) resistor
R1 (VDD VOUT1) resistor
R0 (VDD VOUT2) resistor
