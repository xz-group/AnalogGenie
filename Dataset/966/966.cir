M2 (VOUT1 VB2 net10 VDD) pmos4
M1 (net10 VB1 VDD VDD) pmos4
M0 (net10 VB1 VDD VDD) pmos4
M5 (net10 VIN1 VSS VSS) nmos4
M4 (net20 VB4 VSS VSS) nmos4
M3 (VOUT1 VB3 net20 VSS) nmos4
