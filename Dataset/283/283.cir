M3 (VOUT2 VIN2 IB1 VSS) nmos4
M1 (VOUT1 VIN1 IB1 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT2 VSS) capacitor
M9 (VOUT2 VB1 VDD VDD) pmos4
M8 (VOUT1 VB1 VDD VDD) pmos4
