MM7 (VOUT1 VIN2 net11 net18) pmos4
MM6 (net13 VIN1 net11 net18) pmos4
MM5 (net11 net1004 VDD VDD) pmos4
MM1 (VOUT1 net17 net20 VSS) nmos4
MM0 (net13 net17 net19 VSS) nmos4
MM9 (net20 net13 VSS VSS) nmos4
MM8 (net19 net13 VSS VSS) nmos4
MM10 (net1004 net1007 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM0 (net1007 net1007 VSS VSS) nmos4
MM1 (net10 net1007 VSS VSS) nmos4
MM2 (net1007 net10 VDD VDD) pmos4
RRF (VDD net1007) resistor
RR0 (VDD net10) resistor
