M4 (VOUT1 net22 VDD VDD) pmos4
M3 (net22 net16 VDD VDD) pmos4
M2 (net16 net12 VDD VDD) pmos4
M1 (net12 net31 VDD VDD) pmos4
M0 (net30 net31 VDD VDD) pmos4
M10 (net9 VB1 VSS VSS) nmos4
M9 (net12 VIN1 net9 VSS) nmos4
M8 (net30 VIN2 net9 VSS) nmos4
M7 (net16 VB1 VSS VSS) nmos4
M6 (VOUT1 net22 VSS VSS) nmos4
M5 (net22 net16 VSS VSS) nmos4
C0 (VOUT1 VSS) capacitor
