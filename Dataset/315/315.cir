M3 (VOUT2 VIN2 net25 VSS) nmos4
M1 (VOUT1 VIN1 net24 VSS) nmos4
M0 (net24 VOUT1 VSS VSS) nmos4
M2 (net25 VOUT2 VSS VSS) nmos4
M11 (VOUT2 IB1 VDD VDD) pmos4
M10 (VOUT1 IB1 VDD VDD) pmos4
M4 (IB1 IB1 VDD VDD) pmos4
