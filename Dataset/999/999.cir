M0 (IB1 net64 VDD VDD) pmos4
M5 (net60 VIN1 net58 VDD) pmos4
M4 (net56 VIN2 net58 VDD) pmos4
M2 (net61 net64 VDD VDD) pmos4
M1 (net58 net64 VDD VDD) pmos4
Q0 (VDD net61 VOUT1 0) npn
M11 (VOUT1 net60 VSS VSS) nmos4
M9 (net61 net60 VSS VSS) nmos4
M8 (net60 net56 VSS VSS) nmos4
M7 (net56 net56 VSS VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (net61 net60) capacitor
R0 (VOUT1 VSS) resistor
