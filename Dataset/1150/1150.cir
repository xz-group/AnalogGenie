M1 (IB1 IB1 VDD VDD) pmos4
M0 (net12 IB1 VDD VDD) pmos4
L2 (net22 net10) inductor
L1 (net12 net10) inductor
L0 (net12 net22) inductor
M7 (IB3 net10 VSS VSS) nmos4
M6 (IB2 net22 VSS VSS) nmos4
M5 (net22 net10 VSS VSS) nmos4
M4 (net10 net22 VSS VSS) nmos4
M3 (VB1 net22 VB1 VSS) nmos4
M2 (VB1 net10 VB1 VSS) nmos4
