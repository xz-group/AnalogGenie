M4 (VOUT1 IB1 VSS VSS) nmos4
M6 (VOUT2 IB1 VSS VSS) nmos4
M3 (net038 VIN1 net06 VSS) nmos4
M10 (net040 VIN2 net06 VSS) nmos4
M11 (net034 VB1 net038 VSS) nmos4
M1 (net036 VB1 net040 VSS) nmos4
M8 (net06 net036 VSS VSS) nmos4
M9 (net06 net034 VSS VSS) nmos4
R1 (VOUT2 IB1) resistor
R0 (IB1 VOUT1) resistor
M5 (VOUT1 net034 VDD VDD) pmos4
M7 (VOUT2 net036 VDD VDD) pmos4
M12 (net034 VB2 net037 VDD) pmos4
M13 (net036 VB2 net039 VDD) pmos4
M14 (net037 VB3 VDD VDD) pmos4
M15 (net039 VB3 VDD VDD) pmos4
