M4 (net23 VB1 VSS VSS) nmos4
M3 (VOUT1 VIN2 net23 VSS) nmos4
M2 (net22 VIN1 net23 VSS) nmos4
M0 (net22 net22 VDD VDD) pmos4
M1 (VOUT1 net22 VDD VDD) pmos4
