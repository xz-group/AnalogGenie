I0 (VCONT1 net7 VDD VSS) INVERTER
M3 (VCLK3 net7 VCLK2 VSS) nmos4
M2 (VCLK4 VCONT1 VCLK2 VSS) nmos4
M1 (VCLK3 VCONT1 VCLK1 VSS) nmos4
M0 (VCLK4 net7 VCLK1 VSS) nmos4
