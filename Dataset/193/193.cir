M1 (VOUT1 VIN1 VSS VSS) nmos4
M0 (VOUT1 VIN2 VSS VSS) nmos4
R1 (VDD VOUT1) resistor
R0 (VDD VOUT1) resistor
