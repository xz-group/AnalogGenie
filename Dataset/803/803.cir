M20 (net021 VCLK2 net92 net05) nmos4
M19 (net021 VCLK1 net05 net05) nmos4
M18 (net84 VCLK2 net010 VSS) nmos4
M17 (net010 VCLK1 net05 net05) nmos4
M15 (net07 VCLK1 net05 net05) nmos4
M14 (VIN1 VCLK2 net07 net05) nmos4
M10 (net92 VCLK1 VOUT1 VSS) nmos4
M13 (net78 VCLK1 net92 VSS) nmos4
M11 (net78 VCLK2 VSS VSS) nmos4
M16 (VIN1 VCLK1 net75 VSS) nmos4
M9 (net82 net84 IB1 VSS) nmos4
M8 (net87 VSS IB1 VSS) nmos4
M5 (net92 VB2 net90 VSS) nmos4
M4 (net77 VB2 net91 VSS) nmos4
M12 (net75 VCLK2 VSS VSS) nmos4
M7 (net90 net77 VSS VSS) nmos4
M6 (net91 net77 VSS VSS) nmos4
C3 (net021 net010) capacitor
C0 (net010 net07) capacitor
C1 (net84 net78) capacitor
C2 (net84 net75) capacitor
C4 (net84 net92) capacitor
M1 (net82 VB3 VDD VDD) pmos4
M0 (net87 VB3 VDD VDD) pmos4
M3 (net92 VB1 net82 VDD) pmos4
M2 (net77 VB1 net87 VDD) pmos4
