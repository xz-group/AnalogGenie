C8 (VOUT2 VSS) capacitor
C7 (VOUT3 VSS) capacitor
C6 (VOUT4 VSS) capacitor
C5 (VOUT1 VSS) capacitor
C0 (VIN1 VOUT3) capacitor
C1 (VIN4 VOUT2) capacitor
C2 (VIN3 VOUT4) capacitor
C3 (VIN2 VOUT1) capacitor
R0 (VOUT3 VIN4) resistor
R1 (VOUT2 VIN3) resistor
R2 (VOUT4 VIN2) resistor
R3 (VOUT1 VIN1) resistor
