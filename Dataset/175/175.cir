M1 (IB1 VB1 VOUT1 VDD) pmos4
R0 (VIN1 IB1) resistor
R1 (VDD VOUT1) resistor
M0 (VOUT1 VB2 IB1 VSS) nmos4
