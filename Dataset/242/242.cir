M1 (net34 VB1 IB1 VSS) nmos4
M0 (VOUT1 net25 IB1 VSS) nmos4
C1 (VIN1 net25) capacitor
C0 (net25 VOUT1) capacitor
M2 (VOUT1 net34 VDD VDD) pmos4
M3 (net34 net34 VDD VDD) pmos4
