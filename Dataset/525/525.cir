C1 (VDD net016) capacitor
C0 (VDD net014) capacitor
M3 (net014 net016 IB1 VSS) nmos4
M0 (net016 net014 IB1 VSS) nmos4
R0 (VDD net016) resistor
R2 (VDD net014) resistor
L0 (VDD net016) inductor
L2 (VDD net014) inductor
