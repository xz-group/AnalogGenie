Q3 (net05 net05 VSS 0) npn
Q2 (net04 net05 VSS 0) npn
Q1 (IB1 IB1 net04 0) npn
Q0 (IOUT1 IB1 net05 0) npn
