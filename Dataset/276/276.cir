R1 (VOUT1 net14) resistor
R0 (net14 VSS) resistor
M1 (VOUT1 net8 VSS VSS) nmos4
M0 (net8 VIN1 net14 VSS) nmos4
M3 (VOUT1 VB1 VDD VDD) pmos4
M2 (net8 VB1 VDD VDD) pmos4
