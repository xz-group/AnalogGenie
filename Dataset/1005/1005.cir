M26 (net62 VB5 net53 VDD) pmos4
M25 (net75 VB5 net29 VDD) pmos4
M24 (net53 VB4 VDD VDD) pmos4
M23 (net29 VB4 VDD VDD) pmos4
M14 (net87 VB2 net58 VDD) pmos4
M13 (net28 VB2 net32 VDD) pmos4
M12 (net58 VB1 VDD VDD) pmos4
M9 (net32 VB1 VDD VDD) pmos4
M6 (VOUT1 net87 net89 VDD) pmos4
M5 (VOUT2 net28 net23 VDD) pmos4
M4 (net89 VB9 VDD VDD) pmos4
M3 (net23 VB9 VDD VDD) pmos4
M2 (net72 VIN1 net16 VDD) pmos4
M1 (net88 VIN2 net16 VDD) pmos4
M0 (net16 VB7 VDD VDD) pmos4
M34 (net62 VB6 VSS VSS) nmos4
M33 (net52 VB6 VSS VSS) nmos4
M32 (net39 VB6 VSS VSS) nmos4
M31 (net75 VB6 VSS VSS) nmos4
M30 (net53 net88 net52 VSS) nmos4
M29 (net29 VSS net52 VSS) nmos4
M28 (net53 VSS net39 VSS) nmos4
M27 (net29 net72 net39 VSS) nmos4
M22 (net87 VB3 VSS VSS) nmos4
M21 (net57 VB3 VSS VSS) nmos4
M20 (net42 VB3 VSS VSS) nmos4
M19 (net28 VB3 VSS VSS) nmos4
M18 (net58 net89 net57 VSS) nmos4
M17 (net32 VSS net57 VSS) nmos4
M16 (net58 VSS net42 VSS) nmos4
M15 (net32 net23 net42 VSS) nmos4
M11 (net72 VB8 VSS VSS) nmos4
M10 (net88 VB8 VSS VSS) nmos4
M8 (VOUT1 net62 net88 VSS) nmos4
M7 (VOUT2 net75 net72 VSS) nmos4
