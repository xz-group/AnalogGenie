R1 (VDD net7) resistor
R0 (VIN1 VOUT1) resistor
M0 (net7 VOUT1 VSS VSS) nmos4
C0 (net7 VOUT1) capacitor
