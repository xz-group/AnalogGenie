M0 (VOUT1 net02 VDD VDD) pmos4
M3 (IB1 IB1 VSS VSS) nmos4
M2 (VOUT1 net30 VSS VSS) nmos4
C1 (VDD net02) capacitor
C0 (net30 VIN1) capacitor
R1 (net02 VOUT1) resistor
R0 (net30 IB1) resistor
