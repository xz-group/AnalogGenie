M6 (net28 net23 VDD VDD) pmos4
M5 (net29 net9 VDD VDD) pmos4
M4 (VSS VB1 net26 VDD) pmos4
M1 (net23 net9 VDD VDD) pmos4
M0 (net9 net23 VDD VDD) pmos4
C2 (VCONT1 VSS) capacitor
C1 (VCONT1 net23) capacitor
C0 (VCONT1 net9) capacitor
L5 (net28 VSS) inductor
L4 (net29 VSS) inductor
L3 (net27 net26) inductor
L2 (net23 net27) inductor
L1 (net8 net26) inductor
L0 (net9 net8) inductor
M3 (net27 VCONT2 net26 VSS) nmos4
M2 (net8 VCONT2 net26 VSS) nmos4
