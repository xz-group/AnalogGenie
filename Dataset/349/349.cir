M1 (VOUT1 IIN1 VSS VSS) nmos4
M2 (IB1 IB1 VDD VDD) pmos4
M0 (VOUT1 IB1 VDD VDD) pmos4
C2 (VOUT1 VSS) capacitor
C0 (IIN1 VOUT1) capacitor
