M1 (VOUT2 VIN2 IB1 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
M2 (VOUT1 net36 VDD VDD) pmos4
M3 (VOUT2 net42 VDD VDD) pmos4
C1 (VDD net42) capacitor
C0 (VDD net36) capacitor
R2 (VOUT net42) resistor
R0 (net36 VOUT1) resistor
