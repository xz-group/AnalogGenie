M0 (net10 VIN1 IB1 VSS) nmos4
M1 (net12 VIN2 IB1 VSS) nmos4
M4 (VOUT1 net12 VDD VDD) pmos4
M2 (net12 net10 VDD VDD) pmos4
M3 (net10 net10 VDD VDD) pmos4
R0 (VOUT1 VSS) resistor
