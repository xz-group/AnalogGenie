L0 (VDD VOUT1) inductor
R0 (VIN1 net8) resistor
R1 (VDD VOUT1) resistor
M0 (VOUT1 VB1 net8 VSS) nmos4
M1 (VOUT1 VB3 VDD VDD) pmos4
M2 (VOUT1 VB2 VDD VDD) pmos4
