M6 (VOUT1 VLATCH1 VOUT2 VDD) pmos4
M5 (net29 VLATCH1 VOUT1 VDD) pmos4
M4 (net9 VLATCH1 VOUT2 VDD) pmos4
M1 (VOUT2 VOUT1 VDD VDD) pmos4
M0 (VOUT1 VOUT2 VDD VDD) pmos4
M13 (net29 VIN1 net29 VSS) nmos4
M12 (net9 VIN2 net9 VSS) nmos4
M11 (net9 VIN1 IB1 VSS) nmos4
M10 (net29 VIN2 IB1 VSS) nmos4
M9 (net24 VLATCH1 VSS VSS) nmos4
M8 (VOUT2 VOUT1 net24 VSS) nmos4
M7 (VOUT1 VOUT2 net24 VSS) nmos4
M3 (VDD VLATCH1 net29 VSS) nmos4
M2 (VDD VLATCH1 net9 VSS) nmos4
