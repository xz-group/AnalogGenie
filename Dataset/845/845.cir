Q3 (IB1 IB1 VSS 0) npn
Q2 (net9 IB1 VSS 0) npn
Q1 (VOUT1 VIN2 net9 0) npn
Q0 (net14 VIN1 net9 0) npn
R1 (VDD VOUT1) resistor
R0 (VDD net14) resistor
