M18 (VOUT1 net73 VSS VSS) nmos4
M17 (VOUT2 net73 VSS VSS) nmos4
M14 (net94 net73 VSS VSS) nmos4
M13 (net95 net73 VSS VSS) nmos4
M9 (net99 VREF1 IB1 VSS) nmos4
M8 (net97 net95 IB1 VSS) nmos4
M5 (net73 VB2 net100 VSS) nmos4
M4 (net98 VB2 net96 VSS) nmos4
M7 (net100 net98 VSS VSS) nmos4
M6 (net96 net98 VSS VSS) nmos4
M19 (net82 VCONT1 VDD VDD) pmos4
M16 (VOUT1 VIN2 net82 VDD) pmos4
M15 (VOUT2 VIN1 net82 VDD) pmos4
M12 (net94 VREF2 net76 VDD) pmos4
M11 (net95 VSS net76 VDD) pmos4
M10 (net76 VCONT1 VDD VDD) pmos4
M0 (net97 VB3 VDD VDD) pmos4
M1 (net99 VB3 VDD VDD) pmos4
M3 (net73 VB1 net99 VDD) pmos4
M2 (net98 VB1 net97 VDD) pmos4
