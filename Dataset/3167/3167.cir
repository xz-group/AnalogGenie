MM12 (net12 VB1 net37 VDD) pmos4
MM11 (net23 VB1 net36 VDD) pmos4
MM10 (net10 VB1 net35 VDD) pmos4
MM9 (VOUT1 VB1 net34 VDD) pmos4
MM2 (net37 net12 VDD VDD) pmos4
MM1 (net36 net23 VDD VDD) pmos4
MM6 (net35 net12 VDD VDD) pmos4
MM5 (net34 net23 VDD VDD) pmos4
MM14 (net10 net1003 net33 VSS) nmos4
MM13 (VOUT1 net1003 net31 VSS) nmos4
MM3 (net23 VSS net17 VSS) nmos4
MM0 (net12 net23 net17 VSS) nmos4
MM4 (net17 VB2 VSS VSS) nmos4
MM8 (net33 net10 VSS VSS) nmos4
MM7 (net31 net10 VSS VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
M14 (VIN1 VCLK1 net21 VSS) nmos4
M15 (net22 VCLK2 net23 VSS) nmos4
M13 (net22 VCLK1 VSS VSS) nmos4
M12 (net21 VCLK2 VSS VSS) nmos4
C1 (net23 VOUT1) capacitor
C0 (net22 net21) capacitor
