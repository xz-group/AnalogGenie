M4 (IB1 IB1 VSS VSS) nmos4
M7 (net12 VCONT4 VSS VSS) nmos4
M6 (IB1 VCONT3 net12 VSS) nmos4
M5 (net20 net12 VSS VSS) nmos4
M3 (net10 VCONT1 IB2 VDD) pmos4
M2 (net10 VCONT2 VDD VDD) pmos4
M1 (net20 net10 VDD VDD) pmos4
M0 (IB2 IB2 VDD VDD) pmos4
C1 (IB1 VSS) capacitor
C0 (VDD IB2) capacitor
