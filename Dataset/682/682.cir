M5 (IB1 IB1 net02 VSS) nmos4
M4 (net02 net02 VSS VSS) nmos4
M2 (net014 VIN1 VSS VSS) nmos4
M0 (VOUT1 IB1 net014 VSS) nmos4
M1 (VOUT1 IB2 VDD VDD) pmos4
M3 (IB2 IB2 VDD VDD) pmos4
