M15 (net17 VCLK1 net6 VSS) nmos4
M14 (net6 VCLK2 VSS VSS) nmos4
M13 (VOUT1 net26 VSS VSS) nmos4
M12 (net26 net15 VSS VSS) nmos4
M11 (net15 net15 VSS VSS) nmos4
M10 (net10 VB1 VSS VSS) nmos4
M9 (net21 net15 VSS VSS) nmos4
M8 (net24 VSS net21 net21) nmos4
M7 (net19 net17 net21 net21) nmos4
M5 (net31 net31 net15 net15) nmos4
M6 (VDD net24 net26 VDD) nmos4
M4 (VOUT1 net24 VDD VDD) pmos4
M3 (net19 net19 VDD VDD) pmos4
M2 (net24 net19 VDD VDD) pmos4
M1 (net10 net10 VDD VDD) pmos4
M0 (net31 net10 VDD VDD) pmos4
R2 (VIN1 net6) resistor
R1 (net6 VOUT1) resistor
R0 (net24 net41) resistor
C1 (net17 VOUT1) capacitor
C0 (net41 VOUT1) capacitor
