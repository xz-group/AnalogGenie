MM10 (net27 net12 VSS VSS) nmos4
MM9 (net21 net12 VSS VSS) nmos4
MM8 (net12 net1003 net27 VSS) nmos4
MM7 (net14 net1003 net21 VSS) nmos4
MM3 (net32 VREF1 net10 VSS) nmos4
MM0 (net26 net38 net10 VSS) nmos4
MM4 (net10 VB2 VSS VSS) nmos4
MM6 (net12 VB3 net26 VDD) pmos4
MM5 (net14 VB3 net32 VDD) pmos4
MM1 (net32 VB1 VDD VDD) pmos4
MM2 (net26 VB1 VDD VDD) pmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB5 VB4 VSS) nmos4
MM0 (VB5 VB4 VSS VSS) nmos4
MM4 (VB4 net15 VSS VSS) nmos4
MM5 (net15 net15 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB5 net1006 VDD VDD) pmos4
MM6 (net15 net1006 VDD VDD) pmos4
R3 (VOUT1 VSS) resistor
R2 (net44 VSS) resistor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
C0 (VOUT1 net44) capacitor
M7 (net30 net16 VSS VSS) nmos4
M6 (net24 net14 IB1 IB1) nmos4
M5 (VDD net17 net30 VSS) nmos4
M3 (net16 net16 VSS VSS) nmos4
M0 (VIN1 net30 VOUT1 VOUT1) nmos4
M9 (VSS IB1 net30 VSS) pmos4
M8 (net30 net24 VDD VDD) pmos4
M4 (net24 net24 VDD VDD) pmos4
M2 (net16 net14 net17 VDD) pmos4
M1 (net17 VB6 VDD VDD) pmos4
