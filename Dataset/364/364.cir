M4 (net035 VB1 net040 VSS) nmos4
M11 (net032 VB1 net041 VSS) nmos4
M3 (net041 VIN1 net034 VSS) nmos4
M10 (net040 VIN2 net034 VSS) nmos4
M6 (VOUT2 VB4 VSS VSS) nmos4
M1 (VOUT1 VB4 VSS VSS) nmos4
M8 (net034 VB5 VSS VSS) nmos4
M15 (net21 VB3 VDD VDD) pmos4
M14 (net16 VB3 VDD VDD) pmos4
M13 (net035 VB2 net21 net21) pmos4
M12 (net032 VB2 net16 net16) pmos4
M7 (VOUT2 net035 VDD VDD) pmos4
M5 (VOUT1 net032 VDD VDD) pmos4
