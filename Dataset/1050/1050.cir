M18 (net42 VIN3 net57 VDD) pmos4
M17 (net57 VB2 VDD VDD) pmos4
M11 (net39 VCLK1 VDD VDD) pmos4
M10 (net13 VCLK1 VDD VDD) pmos4
M3 (VOUT1 VOUT2 net37 VDD) pmos4
M2 (VOUT2 VOUT1 net19 VDD) pmos4
M1 (net37 net39 VDD VDD) pmos4
M0 (net19 net13 VDD VDD) pmos4
M20 (net56 VB3 VSS VSS) nmos4
M19 (net42 VIN4 net56 VSS) nmos4
M16 (net39 net42 net16 VSS) nmos4
M15 (net13 VB1 net16 VSS) nmos4
M14 (net16 VCLK1 VSS VSS) nmos4
M13 (net39 VIN1 net16 VSS) nmos4
M12 (net13 VIN2 net16 VSS) nmos4
M9 (VOUT2 net13 VSS VSS) nmos4
M8 (VOUT1 net39 VSS VSS) nmos4
M7 (VOUT1 VOUT2 VSS VSS) nmos4
M6 (VOUT2 VOUT1 VSS VSS) nmos4
M5 (net37 net39 VSS VSS) nmos4
M4 (net19 net13 VSS VSS) nmos4
C0 (net42 VSS) capacitor
