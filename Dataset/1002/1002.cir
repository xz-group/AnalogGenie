M3 (net22 IB1 VDD VDD) pmos4
M2 (net17 IB1 VDD VDD) pmos4
M1 (net9 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M8 (VOUT1 net22 VSS VSS) nmos4
M7 (net22 net22 VSS VSS) nmos4
M6 (net17 net9 VSS VSS) nmos4
M5 (net9 net9 VSS VSS) nmos4
M4 (VDD net17 VOUT1 VSS) nmos4
R1 (net17 net9) resistor
R0 (net9 VIN1) resistor
