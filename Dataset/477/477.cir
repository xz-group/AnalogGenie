M2 (net011 net018 IB1 VDD) pmos4
M3 (VDD net013 VOUT1 VSS) nmos4
M1 (VOUT1 net018 VSS VSS) nmos4
M0 (net011 net018 VSS VSS) nmos4
C1 (VSS IB1) capacitor
C2 (net011 net013) capacitor
R1 (net018 net011) resistor
R0 (VIN1 net018) resistor
R2 (net013 VDD) resistor
