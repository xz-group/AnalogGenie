Q3 (net9 net9 VSS 0) npn
Q2 (IB1 net7 VSS 0) npn
Q1 (IOUT1 IB1 net9 0) npn
Q0 (VDD IB1 net7 0) npn
R0 (net7 VSS) resistor
