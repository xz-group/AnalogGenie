R3 (net21 net40) resistor
R2 (net20 net8) resistor
R1 (net22 net42) resistor
R0 (net19 net9) resistor
L3 (VDD net21) inductor
L2 (VDD net20) inductor
L1 (VDD net22) inductor
L0 (VDD net19) inductor
M11 (net42 VCLK2 IB2 VSS) nmos4
M10 (net39 VCLK1 IB2 VSS) nmos4
M9 (net4 VCLK2 IB1 VSS) nmos4
M8 (net2 VCLK1 IB1 VSS) nmos4
M7 (net8 net40 net39 VSS) nmos4
M6 (net40 net8 net39 VSS) nmos4
M5 (net40 net42 net43 VSS) nmos4
M4 (net8 net9 net43 VSS) nmos4
M3 (net9 net42 net4 VSS) nmos4
M2 (net42 net9 net4 VSS) nmos4
M1 (net42 net8 net2 VSS) nmos4
M0 (net9 net40 net2 VSS) nmos4
