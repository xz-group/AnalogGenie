M1 (VOUT2 VB2 VSS VSS) nmos4
M8 (VOUT1 VB2 VSS VSS) nmos4
M7 (VOUT2 VB1 VDD VIN2) pmos4
M6 (VOUT1 VB1 VDD VIN1) pmos4
