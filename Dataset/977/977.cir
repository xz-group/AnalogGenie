M9 (VOUT5 VB1 VSS VSS) nmos4
M8 (VDD VIN5 VOUT5 VSS) nmos4
M6 (VDD VDD VOUT4 VSS) nmos4
M5 (VDD VIN3 VOUT3 VSS) nmos4
M1 (VOUT1 VOUT1 VSS VSS) nmos4
M0 (VDD VIN1 VOUT1 VSS) nmos4
M11 (VSS VIN6 VOUT6 VDD) pmos4
M10 (VOUT6 VB2 VDD VDD) pmos4
M7 (VSS VIN4 VOUT4 VDD) pmos4
M4 (VSS VSS VOUT3 VDD) pmos4
M3 (VSS VIN2 VOUT2 VDD) pmos4
M2 (VOUT2 VOUT2 VDD VDD) pmos4
