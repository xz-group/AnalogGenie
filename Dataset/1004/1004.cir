M5 (VOUT1 net18 VDD VDD) pmos4
M4 (net30 net18 VDD VDD) pmos4
M3 (VOUT2 net26 VDD VDD) pmos4
M2 (net12 net26 VDD VDD) pmos4
M1 (net26 VB1 VDD VDD) pmos4
M0 (net18 VB1 VDD VDD) pmos4
C1 (VOUT2 net37) capacitor
C0 (VOUT1 net38) capacitor
R1 (net37 net26) resistor
R0 (net38 net18) resistor
M12 (net30 net30 VSS VSS) nmos4
M11 (VOUT2 net30 VSS VSS) nmos4
M10 (net22 VB2 VSS VSS) nmos4
M9 (net12 net12 VSS VSS) nmos4
M8 (VOUT1 net12 VSS VSS) nmos4
M7 (net26 VIN2 net22 VSS) nmos4
M6 (net18 VIN1 net22 VSS) nmos4
