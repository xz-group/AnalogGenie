M9 (VOUT1 net57 VDD VDD) pmos4
M8 (net51 net55 VDD VDD) pmos4
M0 (net55 net55 VDD VDD) pmos4
M3 (net57 net57 VDD VDD) pmos4
M2 (net55 net57 VDD VDD) pmos4
M1 (net57 net55 VDD VDD) pmos4
M11 (VOUT1 net51 VSS VSS) nmos4
M10 (net51 net51 VSS VSS) nmos4
M7 (IB1 IB1 VSS VSS) nmos4
M6 (net56 IB1 VSS VSS) nmos4
M5 (net57 VIN2 net56 VSS) nmos4
M4 (net55 VIN1 net56 VSS) nmos4
