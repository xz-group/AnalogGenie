M3 (VOUT2 VIN2 VDD VDD) pmos4
M2 (VOUT2 VOUT2 VDD VDD) pmos4
M1 (VOUT1 VOUT1 VDD VDD) pmos4
M0 (VOUT1 VIN1 VDD VDD) pmos4
M7 (net22 VCONT2 IB1 VSS) nmos4
M6 (net23 VCONT1 IB1 VSS) nmos4
M5 (VOUT2 VIN2 net22 VSS) nmos4
M4 (VOUT1 VIN1 net23 VSS) nmos4
