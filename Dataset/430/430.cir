M5 (VOUT2 VOUT1 net16 VSS) nmos4
M4 (VOUT1 VOUT2 net16 VSS) nmos4
M3 (net16 VCONT2 IB2 VSS) nmos4
M2 (IB1 VCONT1 IB2 VSS) nmos4
M1 (VOUT2 VIN2 IB1 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
