M7 (VSS VCM1 IB1 VDD) pmos4
M6 (VOUT1 net36 IB1 VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M5 (VOUT2 net36 IB1 VDD) pmos4
M1 (VOUT2 VB1 VDD VDD) pmos4
M4 (net32 VB2 VSS VSS) nmos4
M3 (VOUT2 VIN2 net32 VSS) nmos4
M2 (VOUT1 VIN1 net32 VSS) nmos4
R1 (net36 VOUT2) resistor
R0 (VOUT1 net36) resistor
