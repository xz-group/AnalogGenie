C0 (VCONT3 VSS) capacitor
C1 (net039 VSS) capacitor
R0 (net039 VCONT3) resistor
M1 (net041 VCONT2 VSS VSS) nmos4
M0 (VCONT3 VB2 net041 VSS) nmos4
M3 (net040 VCONT1 VDD VDD) pmos4
M2 (VCONT3 VB1 net040 VDD) pmos4
