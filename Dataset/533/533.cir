M4 (VCONT1 net026 VCONT1 VSS) nmos4
M1 (VCONT1 net025 VCONT1 VSS) nmos4
M3 (net025 net026 VSS VSS) nmos4
M0 (net026 net025 VSS VSS) nmos4
M5 (net026 net025 VDD VDD) pmos4
M2 (net025 net026 VDD VDD) pmos4
L0 (net026 net025) inductor
