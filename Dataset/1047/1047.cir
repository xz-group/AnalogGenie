M13 (net85 VCLK1 VDD VDD) pmos4
M12 (net71 VCLK1 VDD VDD) pmos4
M0 (net78 VCLK2 VDD VDD) pmos4
M8 (net85 VCLK1 VDD VDD) pmos4
M7 (net71 VCLK1 VDD VDD) pmos4
M2 (VOUT1 VOUT2 net78 VDD) pmos4
M1 (VOUT2 VOUT1 net78 VDD) pmos4
M15 (net88 VCLK3 net77 VSS) nmos4
M14 (net89 VCLK3 net77 VSS) nmos4
M11 (net77 VCLK1 VSS VSS) nmos4
M10 (net85 VIN1 net88 VSS) nmos4
M9 (net71 VIN2 net89 VSS) nmos4
M6 (VOUT1 net85 VSS VSS) nmos4
M5 (VOUT1 VOUT2 VSS VSS) nmos4
M4 (VOUT2 VOUT1 VSS VSS) nmos4
M3 (VOUT2 net71 VSS VSS) nmos4
