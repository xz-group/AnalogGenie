R1 (VOUT1 VSS) resistor
R0 (net104 VSS) resistor
M9 (net105 VREF1 IB1 VSS) nmos4
M8 (net107 net104 IB1 VSS) nmos4
M5 (net87 VB2 net103 VSS) nmos4
M4 (net106 VB2 net108 VSS) nmos4
M7 (net103 net106 VSS VSS) nmos4
M6 (net108 net106 VSS VSS) nmos4
M17 (VOUT1 VB6 net91 VDD) pmos4
M16 (VSS VCLK2 net91 VDD) pmos4
M15 (net91 net87 VDD VDD) pmos4
M14 (VOUT1 VB5 net88 VDD) pmos4
M13 (VSS VCLK1 net88 VDD) pmos4
M12 (net88 net87 VDD VDD) pmos4
M11 (net104 VB4 net102 VDD) pmos4
M10 (net102 net87 VDD VDD) pmos4
M0 (net107 VB3 VDD VDD) pmos4
M1 (net105 VB3 VDD VDD) pmos4
M3 (net87 VB1 net105 VDD) pmos4
M2 (net106 VB1 net107 VDD) pmos4
