M2 (VOUT1 IIN1 VSS VSS) nmos4
R1 (VOUT1 VDD) resistor
R0 (VSS VOUT1) resistor
C0 (IIN1 VOUT1) capacitor
