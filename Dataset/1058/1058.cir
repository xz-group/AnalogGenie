M6 (net14 VCLK1 net19 VDD) pmos4
M5 (VOUT2 VCLK1 VDD VDD) pmos4
M4 (net19 net14 VDD VDD) pmos4
M3 (net19 VCLK1 VDD VDD) pmos4
M2 (net14 VCLK1 VDD VDD) pmos4
M1 (net14 net19 VDD VDD) pmos4
M0 (VOUT1 VCLK1 VDD VDD) pmos4
M11 (net17 VCLK1 VSS VSS) nmos4
M10 (VOUT2 VIN2 net17 VSS) nmos4
M9 (VOUT1 VIN1 net17 VSS) nmos4
M8 (net19 net14 VOUT2 VSS) nmos4
M7 (net14 net19 VOUT1 VSS) nmos4
