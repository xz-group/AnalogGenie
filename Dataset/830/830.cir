Q0 (VOUT1 net5 VSS 0) npn
M0 (VOUT1 VIN1 net5 VSS) nmos4
R1 (net5 VSS) resistor
R0 (VDD VOUT1) resistor
