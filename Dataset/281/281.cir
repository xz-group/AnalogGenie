M3 (net13 VIN2 IB1 VSS) nmos4
M2 (VOUT2 VB1 net13 VSS) nmos4
M1 (VOUT1 VB1 net16 VSS) nmos4
M0 (net16 VIN1 IB1 VSS) nmos4
M7 (net14 VB3 VDD VDD) pmos4
M6 (net15 VB3 VDD VDD) pmos4
M5 (VOUT2 VB2 net14 VDD) pmos4
M4 (VOUT1 VB2 net15 VDD) pmos4
