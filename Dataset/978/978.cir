M2 (VOUT1 net13 VDD VDD) pmos4
M1 (net12 net12 VDD VDD) pmos4
M0 (net13 net12 VDD VDD) pmos4
M6 (VOUT1 VB1 VSS VSS) nmos4
M5 (net9 VB1 VSS VSS) nmos4
M4 (net13 VIN2 net9 VSS) nmos4
M3 (net12 VIN1 net9 VSS) nmos4
