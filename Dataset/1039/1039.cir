M1 (LOGICQ2 LOGICQ2 VDD VDD) pmos4
M0 (LOGICQ1 LOGICQ1 VDD VDD) pmos4
M11 (LOGICQ1 net1 net4 VSS) nmos4
M10 (net11 VB1 VSS VSS) nmos4
M9 (net18 VCLK4 net11 VSS) nmos4
M8 (net4 VCLK3 net11 VSS) nmos4
M7 (LOGICQ1 LOGICQ2 net18 VSS) nmos4
M6 (LOGICQ2 LOGICQ1 net18 VSS) nmos4
M5 (LOGICQ2 net5 net4 VSS) nmos4
M4 (LOGICQ2 VCLK2 net5 VSS) nmos4
M3 (LOGICQ1 VCLK1 LOGICQ2 VSS) nmos4
M2 (LOGICQ1 VCLK1 net1 VSS) nmos4
C1 (net5 VIN2) capacitor
C0 (net1 VIN1) capacitor
