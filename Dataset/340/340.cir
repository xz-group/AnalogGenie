M5 (net016 VIN1 IB1 VSS) nmos4
M4 (net04 VB1 net016 VSS) nmos4
M1 (net08 VB1 net019 VSS) nmos4
M3 (net019 VIN2 IB1 VSS) nmos4
M12 (VOUT1 VB4 VSS VSS) nmos4
M11 (VOUT2 VB4 VSS VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT2 VSS) capacitor
M9 (net04 VB2 net017 VDD) pmos4
M8 (net08 VB2 net018 VDD) pmos4
M6 (net017 VB3 VDD VDD) pmos4
M7 (net018 VB3 VDD VDD) pmos4
M13 (VOUT1 net04 VDD VDD) pmos4
M10 (VOUT2 net08 VDD VDD) pmos4
