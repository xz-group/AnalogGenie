M1 (IOUT1 net14 VDD VDD) pmos4
M0 (net14 net14 VDD VDD) pmos4
M7 (net15 VB1 VSS VSS) nmos4
M6 (net9 VB1 VSS VSS) nmos4
M5 (net9 VIN2 net15 VSS) nmos4
M4 (net9 VIN1 net15 VSS) nmos4
M3 (IOUT1 VIN2 net15 VSS) nmos4
M2 (net14 VIN1 net9 VSS) nmos4
