M11 (net24 VREF1 VSS VSS) nmos4
M10 (net2 VREF2 VSS VSS) nmos4
M9 (net24 VIN2 VSS VSS) nmos4
M8 (net2 VIN1 VSS VSS) nmos4
M7 (net25 VOUT2 net24 VSS) nmos4
M6 (net26 VOUT1 net2 VSS) nmos4
M5 (VOUT1 VCLK1 net25 VSS) nmos4
M4 (VOUT2 VCLK1 net26 VSS) nmos4
M3 (VOUT1 VCLK1 VDD VDD) pmos4
M2 (VOUT1 VOUT2 VDD VDD) pmos4
M1 (VOUT2 VOUT1 VDD VDD) pmos4
M0 (VOUT2 VCLK1 VDD VDD) pmos4
