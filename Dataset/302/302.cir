M4 (VOUT1 IB1 net013 VSS) nmos4
M1 (net013 VIN1 VSS VSS) nmos4
R0 (VDD VOUT1) resistor
M0 (IB1 net013 VDD VDD) pmos4
