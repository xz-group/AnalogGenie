M5 (net030 VIN1 IB1 VSS) nmos4
M4 (net032 VIN2 IB1 VSS) nmos4
M6 (VOUT2 VB1 VSS VSS) nmos4
M1 (VOUT1 VB1 VSS VSS) nmos4
M8 (net030 net030 VDD VDD) pmos4
M9 (net032 net032 VDD VDD) pmos4
M7 (VOUT2 net032 VDD VDD) pmos4
M3 (VOUT1 net030 VDD VDD) pmos4
