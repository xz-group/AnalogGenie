M0 (VOUT1 VB1 VSS VSS) nmos4
C2 (VOUT1 VSS) capacitor
C1 (VOUT1 net014) capacitor
C0 (VDD VIN1) capacitor
M1 (VOUT1 VIN1 VDD VDD) pmos4
M3 (net03 net03 VDD VDD) pmos4
M4 (IB1 IB1 net03 VDD) pmos4
M2 (net014 IB1 VIN1 VDD) pmos4
