M0 (VOUT1 IB1 VSS VSS) nmos4
R1 (VDD VOUT1) resistor
R0 (VIN1 IB1) resistor
M1 (IB1 VOUT1 VDD VDD) pmos4
