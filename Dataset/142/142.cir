R3 (VDD VOUT1) resistor
R2 (VDD VOUT2) resistor
R0 (VDD net37) resistor
R1 (VDD net39) resistor
M5 (VOUT2 net37 net41 VSS) nmos4
M4 (VOUT1 net39 net41 VSS) nmos4
M3 (net41 VB2 VSS VSS) nmos4
M2 (net38 VB1 VSS VSS) nmos4
M1 (net39 VIN2 net38 VSS) nmos4
M0 (net37 VIN1 net38 VSS) nmos4
