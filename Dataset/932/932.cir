M9 (VSS VOUT1 net40 VDD) pmos4
M8 (net37 VCM1 net40 VDD) pmos4
M7 (net37 VCM1 net32 VDD) pmos4
M6 (VSS VOUT2 net32 VDD) pmos4
M5 (net40 net15 VDD VDD) pmos4
M4 (net32 net15 VDD VDD) pmos4
M3 (VOUT2 net15 VDD VDD) pmos4
M2 (VOUT1 net15 VDD VDD) pmos4
M1 (net24 net15 VDD VDD) pmos4
M0 (net9 net15 VDD VDD) pmos4
M18 (net9 net9 VSS VSS) nmos4
M17 (net37 net37 VSS VSS) nmos4
M16 (net22 net37 VSS VSS) nmos4
M15 (net22 net9 VSS VSS) nmos4
M14 (net24 net24 net22 VSS) nmos4
M13 (net50 VIN2 net22 VSS) nmos4
M12 (net51 VIN1 net22 VSS) nmos4
M11 (VOUT2 net24 net50 VSS) nmos4
M10 (VOUT1 net24 net51 VSS) nmos4
