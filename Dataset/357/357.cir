M5 (VOUT2 VB1 net018 VSS) nmos4
M4 (VOUT1 VB1 net019 VSS) nmos4
M3 (net018 VIN2 IB1 VSS) nmos4
M1 (net019 VIN1 IB1 VSS) nmos4
M9 (net013 VB3 VDD VDD) pmos4
M8 (net010 VB3 VDD VDD) pmos4
M7 (VOUT2 VB2 net013 net013) pmos4
M6 (VOUT1 VB2 net010 net010) pmos4
