M3 (VOUT1 net28 VDD VDD) pmos4
M2 (VOUT2 net27 VDD VDD) pmos4
M1 (VOUT1 VB3 VDD VDD) pmos4
M0 (VOUT2 VB1 VDD VDD) pmos4
M7 (VOUT1 VB4 VSS VSS) nmos4
M6 (VOUT2 VB2 VSS VSS) nmos4
M5 (net28 VCONT1 VOUT2 VSS) nmos4
M4 (net27 VCONT1 VOUT1 VSS) nmos4
