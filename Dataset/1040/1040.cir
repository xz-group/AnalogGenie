M3 (VOUT1 VB1 VDD VDD) pmos4
M2 (VOUT1 VOUT1 VDD VDD) pmos4
M1 (VOUT2 VOUT2 VDD VDD) pmos4
M0 (VOUT2 VB1 VDD VDD) pmos4
M11 (net21 VB2 VSS VSS) nmos4
M10 (net35 VIN2 net21 VSS) nmos4
M9 (net36 VIN1 net21 VSS) nmos4
M8 (VOUT1 VCLK1 VIN2 VSS) nmos4
M7 (VOUT1 VB3 net35 VSS) nmos4
M6 (VOUT2 VB3 net36 VSS) nmos4
M5 (VOUT2 VCLK1 VIN1 VSS) nmos4
M4 (VOUT2 VCLK2 VOUT1 VSS) nmos4
