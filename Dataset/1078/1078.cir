M14 (VOUT2 VOUT1 net33 VDD) pmos4
M13 (VOUT1 VOUT2 net33 VDD) pmos4
M12 (net33 VCLK2 VDD VDD) pmos4
M3 (net21 net40 VDD VDD) pmos4
M2 (net22 net40 VDD VDD) pmos4
M1 (net14 net40 VDD VDD) pmos4
M0 (net11 net40 VDD VDD) pmos4
M18 (VOUT1 net14 VSS VSS) nmos4
M17 (VOUT2 net22 VSS VSS) nmos4
M16 (VOUT2 VOUT1 VSS VSS) nmos4
M15 (VOUT1 VOUT2 VSS VSS) nmos4
M11 (net18 VCLK1 VSS VSS) nmos4
M10 (net21 VIN4 net18 VSS) nmos4
M9 (net11 VIN3 net18 VSS) nmos4
M8 (net20 VCLK1 VSS VSS) nmos4
M7 (net21 VIN2 net20 VSS) nmos4
M6 (net11 VIN1 net20 VSS) nmos4
M5 (net22 net49 net21 VSS) nmos4
M4 (net14 net49 net11 VSS) nmos4
