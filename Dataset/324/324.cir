M5 (VOUT1 VB1 net033 VSS) nmos4
M4 (net030 VB1 net034 VSS) nmos4
M3 (net033 net030 VSS VSS) nmos4
M1 (net034 net030 VSS VSS) nmos4
M10 (net029 VOUT1 IB1 VSS) nmos4
M11 (net028 VIN1 IB1 VSS) nmos4
C0 (VOUT1 VSS) capacitor
M9 (net029 VB3 VDD VDD) pmos4
M8 (net028 VB3 VDD VDD) pmos4
M7 (VOUT1 VB2 net029 VDD) pmos4
M6 (net030 VB2 net028 VDD) pmos4
