M3 (VOUT2 VOUT2 VDD VDD) pmos4
M2 (IB1 IB1 VDD VDD) pmos4
M1 (VOUT1 VOUT1 VDD VDD) pmos4
M6 (VOUT1 IB1 VDD VDD) pmos4
M7 (VOUT2 IB1 VDD VDD) pmos4
M5 (VOUT2 VIN2 IB2 VSS) nmos4
M0 (VOUT1 VIN1 IB2 VSS) nmos4
