M1 (net15 net14 VSS VSS) nmos4
L2 (net12 net15) inductor
L1 (net14 net16) inductor
L0 (net16 net15) inductor
C3 (net12 net14) capacitor
C2 (net12 net15) capacitor
C1 (net14 net16) capacitor
C0 (net16 net15) capacitor
M0 (net16 net12 VDD VDD) pmos4
