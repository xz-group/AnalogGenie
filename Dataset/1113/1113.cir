M0 (net11 VB1 VDD VDD) pmos4
L5 (VDD net19) inductor
L4 (VDD net17) inductor
L3 (VDD net7) inductor
L2 (VDD net4) inductor
L1 (net11 net21) inductor
L0 (net11 net20) inductor
C3 (VOUT2 net19) capacitor
C2 (VOUT1 net4) capacitor
C1 (VB2 net21) capacitor
C0 (VB2 net20) capacitor
M6 (net19 net17 VSS VSS) nmos4
M5 (net4 net7 VSS VSS) nmos4
M4 (net17 net21 VSS VSS) nmos4
M3 (net7 net20 VSS VSS) nmos4
M2 (net21 net20 VSS VSS) nmos4
M1 (net20 net21 VSS VSS) nmos4
