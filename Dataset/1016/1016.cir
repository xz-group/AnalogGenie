M9 (net41 net41 VDD VDD) pmos4
M8 (VOUT2 net41 net53 VDD) pmos4
M7 (net11 net11 VDD VDD) pmos4
M6 (VOUT1 net11 net54 VDD) pmos4
M5 (net54 net19 VDD VDD) pmos4
M4 (net19 net19 VDD VDD) pmos4
M3 (net35 net19 VDD VDD) pmos4
M2 (net53 net47 VDD VDD) pmos4
M1 (net47 net47 VDD VDD) pmos4
M0 (net15 net47 VDD VDD) pmos4
M21 (net51 net49 VSS VSS) nmos4
M20 (net49 net49 VSS VSS) nmos4
M19 (net11 net49 VSS VSS) nmos4
M18 (net41 net20 VSS VSS) nmos4
M17 (net20 net20 VSS VSS) nmos4
M16 (net52 net20 VSS VSS) nmos4
M15 (VOUT2 net35 net51 VSS) nmos4
M14 (net35 net35 VSS VSS) nmos4
M13 (net15 net15 VSS VSS) nmos4
M12 (VOUT1 net15 net52 VSS) nmos4
M11 (net47 VIN2 net20 VSS) nmos4
M10 (net19 VIN1 net49 VSS) nmos4
