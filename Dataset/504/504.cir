M4 (VIF2 VLO1 net1 VSS) nmos4
M1 (VIF1 VLO2 net1 VSS) nmos4
M0 (net13 VRF1 VSS VSS) nmos4
M5 (net1 VRF2 VSS VSS) nmos4
M2 (VIF2 VLO2 net13 VSS) nmos4
M3 (VIF1 VLO1 net13 VSS) nmos4
R1 (VDD VIF2) resistor
R0 (VDD VIF1) resistor
