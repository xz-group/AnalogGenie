M1 (VOUT1 IB1 IB2 VSS) nmos4
M0 (VDD VIN1 IB1 VSS) nmos4
M2 (VOUT1 VOUT1 VDD VDD) pmos4
C0 (IB2 VSS) capacitor
