M6 (VOUT2 VB4 net30 VDD) pmos4
M5 (VOUT1 VB4 net31 VDD) pmos4
M4 (net30 VB2 VDD VDD) pmos4
M3 (net31 VB2 VDD VDD) pmos4
M2 (net25 VIN2 net11 VDD) pmos4
M1 (net24 VIN1 net11 VDD) pmos4
M0 (net11 VB1 VDD VDD) pmos4
M10 (net25 VCM1 VSS VSS) nmos4
M9 (net24 VCM1 VSS VSS) nmos4
M8 (VOUT2 VB3 net25 VSS) nmos4
M7 (VOUT1 VB3 net24 VSS) nmos4
