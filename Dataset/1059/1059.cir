M38 (VOUT1 VSS net0109 net0109) pmos4
M37 (VOUT2 VSS net0109 net0109) pmos4
M36 (net055 VSS net0109 net0109) pmos4
M35 (net046 VSS net0109 net0109) pmos4
M34 (net041 VSS net0109 net0109) pmos4
M33 (net042 VSS net0109 net0109) pmos4
M27 (net0106 VSS VDD VDD) pmos4
M26 (net66 VCLK1 VDD VDD) pmos4
M20 (net68 VSS VDD VDD) pmos4
M19 (net69 VSS VDD VDD) pmos4
M12 (net31 VCLK1 VDD VDD) pmos4
M11 (net46 VSS VDD VDD) pmos4
M10 (net49 VSS VDD VDD) pmos4
M2 (net23 VCLK1 net20 VDD) pmos4
M1 (net20 VSS VDD VDD) pmos4
M0 (net23 VSS VDD VDD) pmos4
M47 (net067 VB1 VSS VSS) nmos4
M46 (net052 VB1 VSS VSS) nmos4
M45 (net034 VB2 VSS VSS) nmos4
M44 (VOUT1 net046 net067 VSS) nmos4
M43 (VOUT2 net055 net067 VSS) nmos4
M42 (net055 net041 net052 VSS) nmos4
M41 (net046 net042 net052 VSS) nmos4
M40 (net041 net49 net034 VSS) nmos4
M39 (net042 net46 net034 VSS) nmos4
M32 (net49 net042 net017 VSS) nmos4
M31 (net46 net041 net017 VSS) nmos4
M30 (net08 VB1 VSS VSS) nmos4
M29 (net017 VCLK2 net08 VSS) nmos4
M28 (net0106 VCLK1 net08 VSS) nmos4
M25 (net48 VB1 VSS VSS) nmos4
M24 (net66 VCLK1 net48 VSS) nmos4
M22 (net46 net49 net66 VSS) nmos4
M21 (net49 net46 net66 VSS) nmos4
M18 (net68 VCLK2 net48 VSS) nmos4
M17 (net39 VB1 VSS VSS) nmos4
M16 (net69 VCLK2 net39 VSS) nmos4
M15 (net31 VCLK1 net39 VSS) nmos4
M14 (net46 net23 net31 VSS) nmos4
M13 (net49 net20 net31 VSS) nmos4
M9 (net19 VB1 VSS VSS) nmos4
M8 (net25 VCLK1 net19 VSS) nmos4
M7 (net11 VCLK2 net19 VSS) nmos4
M6 (net20 net23 net25 VSS) nmos4
M5 (net23 net20 net25 VSS) nmos4
M4 (net20 VIN1 net11 VSS) nmos4
M3 (net23 VIN2 net11 VSS) nmos4
