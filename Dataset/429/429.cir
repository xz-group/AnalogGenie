M1 (VOUT2 VCONT1 VDD VDD) pmos4
M0 (VOUT1 VCONT1 VDD VDD) pmos4
M3 (VOUT2 VIN2 IB1 VSS) nmos4
M2 (VOUT1 VIN1 IB1 VSS) nmos4
C1 (VOUT2 VSS) capacitor
C0 (VOUT1 VSS) capacitor
