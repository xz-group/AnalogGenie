M1 (VOUT1 net5 VSS VSS) nmos4
M2 (IB1 net8 VSS VSS) nmos4
M0 (VOUT1 VOUT1 VDD VDD) pmos4
C1 (net8 VSS) capacitor
C0 (VIN1 net5) capacitor
R0 (net5 net8) resistor
