M7 (net053 net050 VDD VDD) pmos4
M6 (net054 net050 VDD VDD) pmos4
M5 (VOUT1 net050 net053 VDD) pmos4
M4 (net050 net050 net054 VDD) pmos4
M3 (net045 net044 net057 VDD) pmos4
M2 (net044 net044 net058 VDD) pmos4
M1 (net057 net044 VDD VDD) pmos4
M0 (net058 net044 VDD VDD) pmos4
M13 (net044 VIN2 IB1 VSS) nmos4
M8 (net050 VIN1 IB1 VSS) nmos4
M9 (net055 net045 VSS VSS) nmos4
M10 (net056 net045 VSS VSS) nmos4
M11 (VOUT1 net045 net055 VSS) nmos4
M12 (net045 net045 net056 VSS) nmos4
R0 (VOUT1 VSS) resistor
