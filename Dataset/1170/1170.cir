M15 (VOUT3 VOUT1 VDD VDD) pmos4
M10 (VOUT4 VOUT2 VDD VDD) pmos4
M9 (VOUT4 VOUT3 VDD VDD) pmos4
M8 (VOUT3 VOUT4 VDD VDD) pmos4
M3 (VOUT2 VOUT3 VDD VDD) pmos4
M2 (VOUT2 VOUT1 VDD VDD) pmos4
M1 (VOUT1 VOUT2 VDD VDD) pmos4
M0 (VOUT1 VOUT4 VDD VDD) pmos4
L1 (VOUT3 VOUT4) inductor
L0 (VOUT1 VOUT2) inductor
C1 (VOUT4 VOUT3) capacitor
C0 (VOUT2 VOUT1) capacitor
M14 (VOUT4 VOUT2 VSS VSS) nmos4
M13 (VOUT4 VOUT3 VSS VSS) nmos4
M12 (VOUT3 VOUT1 VSS VSS) nmos4
M11 (VOUT3 VOUT4 VSS VSS) nmos4
M7 (VOUT2 VOUT3 VSS VSS) nmos4
M6 (VOUT2 VOUT1 VSS VSS) nmos4
M5 (VOUT1 VOUT4 VSS VSS) nmos4
M4 (VOUT1 VOUT2 VSS VSS) nmos4
