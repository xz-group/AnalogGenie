L0 (net013 IB1) inductor
L1 (net015 IB1) inductor
M4 (VCONT1 net015 VCONT1 VSS) nmos4
M1 (VCONT1 net013 VCONT1 VSS) nmos4
M0 (net015 net013 VDD VDD) pmos4
M3 (net013 net015 VDD VDD) pmos4
