M6 (VOUT1 net35 net40 VDD) pmos4
M5 (net26 net35 VDD VDD) pmos4
M4 (net39 net35 VDD VDD) pmos4
M3 (net40 net21 VDD VDD) pmos4
M2 (net21 net21 VDD VDD) pmos4
M1 (net11 net11 VDD VDD) pmos4
M0 (net8 net11 VDD VDD) pmos4
M14 (net8 net8 VSS VSS) nmos4
M13 (net38 net8 VSS VSS) nmos4
M12 (VOUT1 net26 net38 VSS) nmos4
M11 (net26 net26 VSS VSS) nmos4
M10 (net39 VB1 VSS VSS) nmos4
M9 (net17 VB1 VSS VSS) nmos4
M8 (net21 VIN1 net17 VSS) nmos4
M7 (net11 VIN2 net17 VSS) nmos4
C0 (VOUT1 VSS) capacitor
