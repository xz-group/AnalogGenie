M5 (VOUT1 LOGICB1 IB1 VSS) nmos4
M6 (VOUT2 VB1 IB1 VSS) nmos4
M0 (VOUT1 LOGICA1 IB1 VSS) nmos4
R0 (VDD VOUT1) resistor
R1 (VDD VOUT2) resistor
