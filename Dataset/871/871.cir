Q2 (net5 VIN1 VSS 0) npn
Q0 (VDD net5 VOUT1 0) npn
R1 (VOUT1 VSS) resistor
R0 (VDD net5) resistor
Q1 (VSS net5 VOUT1 0) pnp
