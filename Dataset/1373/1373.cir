MM10 (net27 net12 VSS VSS) nmos4
MM9 (net21 net12 VSS VSS) nmos4
MM8 (net12 net1003 net27 VSS) nmos4
MM7 (net20 net1003 net21 VSS) nmos4
MM3 (net32 net20 net10 VSS) nmos4
MM0 (net26 net13 net10 VSS) nmos4
MM4 (net10 net1001 VSS VSS) nmos4
MM6 (net12 VB2 net26 VDD) pmos4
MM5 (net20 VB2 net32 VDD) pmos4
MM1 (net32 VB1 VDD VDD) pmos4
MM2 (net26 VB1 VDD VDD) pmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (net010 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
RR0 (VB3 net010) resistor
C1 (VOUT1 VSS) capacitor
C0 (VIN1 VSS) capacitor
M1 (net13 net20 VOUT1 VOUT1) pmos4
M0 (net10 VCONT1 VIN1 VIN1) pmos4
M3 (net13 VCONT3 VSS VSS) nmos4
M2 (net10 VCONT2 VSS VSS) nmos4
L0 (net10 net13) inductor
