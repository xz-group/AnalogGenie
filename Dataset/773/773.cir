M3 (VSS VCONT2 net8 VDD) pmos4
M2 (VOUT1 VIN1 net9 VDD) pmos4
M1 (VOUT1 VIN1 net8 VSS) nmos4
M0 (VDD VCONT1 net9 VSS) nmos4
