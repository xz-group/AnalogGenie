M2 (net03 VIN2 VSS VSS) nmos4
M0 (net026 VIN2 VSS VSS) nmos4
M1 (net027 VIN1 VSS VSS) nmos4
M3 (net024 VIN1 VSS VSS) nmos4
M5 (net026 net027 VDD VDD) pmos4
M4 (net027 net027 VDD VDD) pmos4
M11 (net024 net03 VDD VDD) pmos4
M10 (net03 net03 VDD VDD) pmos4
C0 (net026 VSS) capacitor
C2 (net024 VSS) capacitor
