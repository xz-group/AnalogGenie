M3 (IB2 net1 VDD VDD) pmos4
M2 (VOUT1 net1 VDD VDD) pmos4
M4 (IB1 IB1 VSS VSS) nmos4
M1 (VIN1 IB1 VSS VSS) nmos4
M0 (VOUT1 VB1 VIN1 VSS) nmos4
C1 (IB1 VSS) capacitor
C0 (net1 VSS) capacitor
