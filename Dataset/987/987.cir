M4 (net17 VIN1 net13 VDD) pmos4
M3 (net9 VIN2 net13 VDD) pmos4
M2 (VOUT1 net26 VDD VDD) pmos4
M1 (net13 net26 VDD VDD) pmos4
M0 (net29 net26 VDD VDD) pmos4
M11 (net22 VSS net17 VSS) nmos4
M8 (net22 VDD net17 VSS) nmos4
M7 (VOUT1 net17 VSS VSS) nmos4
M6 (net17 net9 VSS VSS) nmos4
M5 (net9 net9 VSS VSS) nmos4
R0 (net29 VSS) resistor
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net22) capacitor
