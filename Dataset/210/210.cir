R2 (VSS VIN1) resistor
R1 (VOUT1 VDD) resistor
M1 (VOUT1 VIN1 VSS VSS) nmos4
M0 (VIN1 VOUT1 VDD VDD) pmos4
