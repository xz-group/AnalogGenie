M7 (VOUT1 IB1 VDD VDD) pmos4
M1 (IB1 IB1 VDD VDD) pmos4
M0 (net21 IB1 VDD VDD) pmos4
M6 (VOUT1 net24 VSS VSS) nmos4
M5 (net24 net19 VSS VSS) nmos4
M4 (net19 net19 VSS VSS) nmos4
M3 (net21 VIN2 net24 VSS) nmos4
M2 (net21 VIN1 net19 VSS) nmos4
R0 (net31 net24) resistor
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net31) capacitor
