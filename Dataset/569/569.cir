M5 (LOGICQ1 VCLK1 VDD VDD) pmos4
M3 (net10 net8 VDD VDD) pmos4
M0 (net8 LOGICD1 VDD VDD) pmos4
M6 (LOGICQ1 net10 VSS VSS) nmos4
M4 (net10 VCLK1 VSS VSS) nmos4
M2 (net13 LOGICD1 VSS VSS) nmos4
M1 (net8 VCLK1 net13 VDD) nmos4
