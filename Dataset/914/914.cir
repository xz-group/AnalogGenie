M4 (net20 VIN2 net15 VDD) pmos4
M3 (net12 VIN1 net15 VDD) pmos4
M2 (VOUT1 IB1 VDD VDD) pmos4
M1 (net15 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M8 (net12 net12 VSS VSS) nmos4
M7 (net20 net12 VSS VSS) nmos4
M6 (VOUT1 net20 VSS VSS) nmos4
M5 (net29 VCONT1 net20 VSS) nmos4
C0 (VOUT1 net29) capacitor
