M3 (VIN1 VCLK1 net2 VSS) nmos4
M4 (net2 VCLK2 VOUT1 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (net2 VSS) capacitor
