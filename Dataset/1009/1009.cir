M5 (VOUT2 net18 VB1 VDD) pmos4
M4 (VOUT1 net13 VB1 VDD) pmos4
M3 (net18 VB2 VDD VDD) pmos4
M2 (net13 VB2 VDD VDD) pmos4
M1 (VB1 VOUT2 VDD VDD) pmos4
M0 (VB1 VOUT1 VDD VDD) pmos4
C1 (VOUT2 net31) capacitor
C0 (VOUT1 net32) capacitor
R1 (net31 net18) resistor
R0 (net32 net13) resistor
M10 (VOUT1 VB3 VSS VSS) nmos4
M9 (VOUT2 VB3 VSS VSS) nmos4
M8 (net35 VB3 VSS VSS) nmos4
M7 (net18 VIN2 net35 VSS) nmos4
M6 (net13 VIN1 net35 VSS) nmos4
