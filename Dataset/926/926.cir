M4 (net23 VIN2 net17 VDD) pmos4
M3 (net12 VIN1 net17 VDD) pmos4
M2 (VOUT1 VB1 VDD VDD) pmos4
M1 (net17 VCM1 VDD VDD) pmos4
M0 (VOUT2 VB1 VDD VDD) pmos4
M9 (VOUT1 net23 VSS VSS) nmos4
M8 (net23 VB2 VSS VSS) nmos4
M7 (net12 VB2 VSS VSS) nmos4
M5 (VOUT2 net12 VSS VSS) nmos4
C1 (net23 VOUT1) capacitor
C0 (net12 VOUT2) capacitor
