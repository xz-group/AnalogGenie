M4 (net10 VCLK1 VSS VSS) nmos4
M1 (LOGICQ1 LOGICD2 net10 VSS) nmos4
M0 (LOGICQ2 LOGICD1 net10 VSS) nmos4
M3 (LOGICQ1 LOGICQ2 VDD VDD) pmos4
M2 (LOGICQ2 LOGICQ1 VDD VDD) pmos4
