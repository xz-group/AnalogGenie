M9 (net71 VIN2 VSS VSS) nmos4
M8 (net74 VIN1 VSS VSS) nmos4
M7 (net72 VOUT2 net71 VSS) nmos4
M6 (net73 VOUT1 net74 VSS) nmos4
M5 (VOUT1 VCLK1 net72 VSS) nmos4
M4 (VOUT2 VCLK1 net73 VSS) nmos4
M0 (VOUT2 VCLK1 VDD VDD) pmos4
M3 (VOUT1 VCLK1 VDD VDD) pmos4
M2 (VOUT1 VOUT2 VDD VDD) pmos4
M1 (VOUT2 VOUT1 VDD VDD) pmos4
