MM12 (net12 VB1 net37 VDD) pmos4
MM11 (net23 VB1 net36 VDD) pmos4
MM10 (net10 VB1 net35 VDD) pmos4
MM9 (net14 VB1 net34 VDD) pmos4
MM2 (net37 net12 VDD VDD) pmos4
MM1 (net36 net23 VDD VDD) pmos4
MM6 (net35 net12 VDD VDD) pmos4
MM5 (net34 net23 VDD VDD) pmos4
MM14 (net10 net1003 net33 VSS) nmos4
MM13 (net14 net1003 net31 VSS) nmos4
MM3 (net23 VREF1 net17 VSS) nmos4
MM0 (net12 net38 net17 VSS) nmos4
MM4 (net17 VB2 VSS VSS) nmos4
MM8 (net33 net10 VSS VSS) nmos4
MM7 (net31 net10 VSS VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (VB3 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
R3 (VOUT1 VSS) resistor
R2 (net44 VSS) resistor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
C0 (VOUT1 net44) capacitor
M7 (net30 net16 VSS VSS) nmos4
M6 (net24 net14 IB1 IB1) nmos4
M5 (VDD net17 net30 VSS) nmos4
M3 (net16 net16 VSS VSS) nmos4
M0 (VIN1 net30 VOUT1 VOUT1) nmos4
M9 (VSS IB1 net30 VSS) pmos4
M8 (net30 net24 VDD VDD) pmos4
M4 (net24 net24 VDD VDD) pmos4
M2 (net16 net14 net17 VDD) pmos4
M1 (net17 VB4 VDD VDD) pmos4
