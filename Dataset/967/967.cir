M10 (VOUT6 VB2 net57 VDD) pmos4
M9 (VOUT3 VB2 net63 VDD) pmos4
M8 (VOUT4 VB2 net61 VDD) pmos4
M7 (VOUT2 VB2 net64 VDD) pmos4
M6 (net57 VIN3 VDD VDD) pmos4
M5 (net61 VIN2 VDD VDD) pmos4
M4 (net64 VIN1 VDD VDD) pmos4
M3 (VOUT5 VB1 VDD VDD) pmos4
M2 (VSS VB1 VDD VDD) pmos4
M1 (net63 VB1 VDD VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M21 (net57 VB4 VSS VSS) nmos4
M20 (VOUT6 VB4 VSS VSS) nmos4
M19 (net60 VB4 VSS VSS) nmos4
M18 (VOUT2 VB4 VSS VSS) nmos4
M17 (net59 VIN6 VSS VSS) nmos4
M16 (net62 VIN5 VSS VSS) nmos4
M15 (net65 VIN4 VSS VSS) nmos4
M14 (VOUT5 VB3 net59 VSS) nmos4
M13 (VOUT4 VB3 net60 VSS) nmos4
M12 (VOUT3 VB3 net62 VSS) nmos4
M11 (VOUT1 VB3 net65 VSS) nmos4
