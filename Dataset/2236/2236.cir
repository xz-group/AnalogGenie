MM8 (net9 net9 VSS VSS) nmos4
MM7 (net10 net9 VSS VSS) nmos4
MM3 (net20 VREF1 net16 VSS) nmos4
MM0 (net11 net7 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM6 (net9 net11 VDD VDD) pmos4
MM5 (net10 net20 VDD VDD) pmos4
MM1 (net20 net20 VDD VDD) pmos4
MM2 (net11 net11 VDD VDD) pmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
MM2 (net1006 VB1 VSS VSS) nmos4
MM0 (net010 VB1 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB1 net1006 VDD VDD) pmos4
RR0 (VB1 net010) resistor
M0 (VIN1 net10 VOUT1 VOUT1) nmos4
R2 (net11 VSS) resistor
R1 (net7 VSS) resistor
R0 (VOUT1 net7) resistor
C0 (VOUT1 net11) capacitor
