M5 (IOUT2 IB4 VSS VSS) nmos4
M4 (IB2 IB4 VSS VSS) nmos4
M1 (IOUT1 IB3 VSS VSS) nmos4
M0 (IB1 IB3 VSS VSS) nmos4
M6 (IB4 VIN2 IB2 VDD) pmos4
M3 (IB2 VCONT1 IB1 VDD) pmos4
M2 (IB3 VIN1 IB1 VDD) pmos4
