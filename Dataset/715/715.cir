M17 (net42 net44 IB3 VDD) pmos4
M16 (net037 VOUT1 IB3 VDD) pmos4
M15 (net037 VOUT2 IB2 VDD) pmos4
M14 (net42 net44 IB2 VDD) pmos4
M7 (net075 VB1 VDD VDD) pmos4
M6 (net074 VB1 VDD VDD) pmos4
M9 (VOUT1 VB3 net075 VDD) pmos4
M8 (VOUT2 VB3 net074 VDD) pmos4
M13 (net42 net42 VSS VSS) nmos4
M4 (net037 net037 VSS VSS) nmos4
M2 (VB1 VB1 net075 VSS) nmos4
M0 (net074 VIN1 IB1 VSS) nmos4
M5 (net075 VIN2 IB1 VSS) nmos4
M3 (VOUT1 VB2 net079 VSS) nmos4
M10 (VOUT2 VB2 net080 VSS) nmos4
M11 (net079 net42 VSS VSS) nmos4
M12 (net080 net42 VSS VSS) nmos4
M1 (VB1 VB1 net074 VSS) nmos4
