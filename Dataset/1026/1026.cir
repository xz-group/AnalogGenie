M4 (VOUT1 IB1 VDD VDD) pmos4
M3 (net23 IB1 VDD VDD) pmos4
M2 (net18 IB1 VDD VDD) pmos4
M1 (net30 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M9 (VOUT1 net23 VSS VSS) nmos4
M8 (net22 net30 VSS VSS) nmos4
M7 (net15 net30 VSS VSS) nmos4
M6 (net18 VSS net22 VIN1) nmos4
M5 (net18 VSS net15 VIN2) nmos4
R0 (net36 net22) resistor
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net36) capacitor
Q1 (VSS net22 net23 0) pnp
Q0 (VSS net15 net30 0) pnp
