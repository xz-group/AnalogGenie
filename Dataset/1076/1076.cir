M9 (net12 net22 net14 VDD) pmos4
M8 (net22 net12 net14 VDD) pmos4
M4 (VOUT2 VCLK2 VDD VDD) pmos4
M3 (VOUT2 VIN2 net14 VDD) pmos4
M2 (VOUT1 VIN1 net14 VDD) pmos4
M1 (VOUT1 VCLK2 VDD VDD) pmos4
M0 (net14 VCLK1 VDD VDD) pmos4
M12 (net20 VCLK3 VSS VSS) nmos4
M11 (net12 net22 net20 VSS) nmos4
M10 (net22 net12 net20 VSS) nmos4
M7 (net16 VCLK2 VSS VSS) nmos4
M6 (VOUT2 VIN2 net16 VB1) nmos4
M5 (VOUT1 VIN1 net16 VB1) nmos4
