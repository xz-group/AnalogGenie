M9 (net10 VB1 net19 VDD) pmos4
M8 (VOUT1 VB1 net17 VDD) pmos4
M4 (net19 IB1 IB1 VDD) pmos4
M1 (net17 IB1 IB1 VDD) pmos4
M2 (IB1 IB1 VDD VDD) pmos4
M6 (net17 IB1 VDD VDD) pmos4
M7 (net19 IB1 VDD VDD) pmos4
M12 (net25 net10 VSS VSS) nmos4
M11 (net27 net10 VSS VSS) nmos4
M10 (VOUT1 VB2 net25 VSS) nmos4
M3 (net10 VB2 net27 VSS) nmos4
M5 (net19 VIN2 IB2 VSS) nmos4
M0 (net17 VIN1 IB2 VSS) nmos4
C0 (VOUT1 VSS) capacitor
