MM8 (net9 net9 VSS VSS) nmos4
MM7 (VOUT1 net9 VSS VSS) nmos4
MM3 (net20 net7 net16 VSS) nmos4
MM0 (net11 net8 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM6 (net9 net11 VDD VDD) pmos4
MM5 (VOUT1 net20 VDD VDD) pmos4
MM1 (net20 net20 VDD VDD) pmos4
MM2 (net11 net11 VDD VDD) pmos4
MM2 (net1005 net1005 VSS VSS) nmos4
MM10 (VB1 net1007 VSS VSS) nmos4
MM1 (net1005 VB1 VDD VDD) pmos4
MM0 (VB1 VB1 VDD VDD) pmos4
RR1 (net05 VSS) resistor
RRF (VDD net1007) resistor
MM0 (net1007 net1007 net05 VSS) nmos4
Q1 (VSS VSS net13 0) pnp
Q0 (VSS VSS net7 0) pnp
R2 (VOUT1 net7) resistor
R1 (VOUT1 net8) resistor
R0 (net8 net13) resistor
