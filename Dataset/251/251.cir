R3 (VOUT1 VSS) resistor
R2 (net1 VSS) resistor
R1 (net1 VOUT1) resistor
R0 (VDD net2) resistor
M0 (net2 VIN1 net1 VSS) nmos4
M1 (VOUT1 net2 VDD VDD) pmos4
