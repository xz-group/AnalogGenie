M1 (VOUT1 VIN1 IB1 VSS) nmos4
M3 (VOUT2 VIN2 IB1 VSS) nmos4
R1 (VOUT2 net5) resistor
R0 (net5 VOUT1) resistor
M10 (VOUT1 net5 VDD VDD) pmos4
M11 (VOUT2 net5 VDD VDD) pmos4
