MM3 (VOUT1 VSS net13 VSS) nmos4
MM0 (net11 net23 net13 VSS) nmos4
MM4 (net13 net1005 VSS VSS) nmos4
MM6 (net11 net18 net19 VDD) pmos4
MM5 (VOUT1 net18 net20 VDD) pmos4
MM1 (net20 net11 VDD VDD) pmos4
MM2 (net19 net11 VDD VDD) pmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 VDD VDD) pmos4
M14 (VIN1 VCLK1 net21 VSS) nmos4
M15 (net22 VCLK2 net23 VSS) nmos4
M13 (net22 VCLK1 VSS VSS) nmos4
M12 (net21 VCLK2 VSS VSS) nmos4
C1 (net23 VOUT1) capacitor
C0 (net22 net21) capacitor
