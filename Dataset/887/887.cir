M6 (VOUT1 net34 net35 VDD) pmos4
M5 (net33 net34 net18 VDD) pmos4
M4 (net18 net18 VDD VDD) pmos4
M3 (net35 net18 VDD VDD) pmos4
M2 (net27 VIN2 net9 VDD) pmos4
M1 (net24 VIN1 net9 VDD) pmos4
M0 (net9 VB1 VDD VDD) pmos4
M10 (net27 VB3 VSS VSS) nmos4
M9 (net24 VB3 VSS VSS) nmos4
M8 (VOUT1 VB2 net27 VSS) nmos4
M7 (net33 VB2 net24 VSS) nmos4
C0 (VOUT1 VSS) capacitor
