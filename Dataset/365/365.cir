M1 (VOUT1 net048 VSS VSS) nmos4
M8 (net050 VB4 VSS VSS) nmos4
M3 (net054 VIN1 net050 VSS) nmos4
M4 (net051 VB1 net055 VSS) nmos4
M11 (net049 VB1 net054 VSS) nmos4
M6 (VOUT2 net048 VSS VSS) nmos4
M10 (net055 VIN2 net050 VSS) nmos4
M5 (VOUT1 net049 VDD VDD) pmos4
M7 (VOUT2 net051 VDD VDD) pmos4
M12 (net049 VB2 net45 net45) pmos4
M13 (net051 VB2 net42 net42) pmos4
M14 (net45 VB3 VDD VDD) pmos4
M15 (net42 VB3 VDD VDD) pmos4
R1 (net048 VOUT2) resistor
R0 (VOUT1 net048) resistor
