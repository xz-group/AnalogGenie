M1 (net04 VIN1 VSS VSS) nmos4
M0 (VOUT1 VB2 net04 VSS) nmos4
M2 (net04 VB1 VDD VDD) pmos4
R0 (VDD VOUT1) resistor
