M2 (VOUT2 VIN2 net015 VSS) nmos4
M0 (VOUT1 VIN1 net015 VSS) nmos4
M1 (net015 VB1 VSS VSS) nmos4
M5 (VOUT1 VB1 VDD VDD) pmos4
M4 (VOUT2 VOUT2 VDD VDD) pmos4
M3 (VOUT1 VOUT1 VDD VDD) pmos4
M6 (VOUT2 VB1 VDD VDD) pmos4
