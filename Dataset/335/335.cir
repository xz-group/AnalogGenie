M10 (VOUT2 net015 VSS VSS) nmos4
M9 (net018 net013 VSS VSS) nmos4
M3 (net011 net015 VSS VSS) nmos4
M2 (VOUT1 net013 VSS VSS) nmos4
M1 (net015 VB1 VSS VSS) nmos4
M8 (net013 VB1 VSS VSS) nmos4
M11 (net018 net018 VDD VDD) pmos4
M5 (VOUT2 net018 VDD VDD) pmos4
M4 (net011 net011 VDD VDD) pmos4
M0 (VOUT1 net011 VDD VDD) pmos4
M7 (net015 VIN2 IB1 VDD) pmos4
M6 (net013 VIN1 IB1 VDD) pmos4
