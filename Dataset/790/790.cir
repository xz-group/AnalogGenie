M15 (net73 VCLK2 net74 VSS) nmos4
M14 (VIN1 VCLK1 net71 VSS) nmos4
M13 (net73 VCLK1 VSS VSS) nmos4
M12 (net71 VCLK2 VSS VSS) nmos4
M9 (net79 net74 IB1 VSS) nmos4
M8 (net81 VSS IB1 VSS) nmos4
M5 (VOUT1 VB2 net85 VSS) nmos4
M4 (net75 VB2 net84 VSS) nmos4
M7 (net85 net75 VSS VSS) nmos4
M6 (net84 net75 VSS VSS) nmos4
C1 (net74 VOUT1) capacitor
C0 (net73 net71) capacitor
M1 (net79 VB3 VDD VDD) pmos4
M0 (net81 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net79 VDD) pmos4
M2 (net75 VB1 net81 VDD) pmos4
