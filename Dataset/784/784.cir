M3 (net25 VIN2 VDD VDD) pmos4
M2 (IOUT2 VIN2 VDD VDD) pmos4
M1 (IOUT1 VIN1 VDD VDD) pmos4
M0 (net27 VIN1 VDD VDD) pmos4
Q9 (net23 net23 VSS 0) npn
Q8 (net25 net25 net23 0) npn
Q7 (net19 net23 VSS 0) npn
Q6 (IOUT1 VCONT2 net19 0) npn
Q5 (IOUT2 VCONT1 net19 0) npn
Q4 (IOUT2 VCONT2 net17 0) npn
Q3 (IOUT1 VCONT1 net17 0) npn
Q2 (net17 net9 VSS 0) npn
Q1 (net9 net9 VSS 0) npn
Q0 (net27 net27 net9 0) npn
