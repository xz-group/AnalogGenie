M1 (IOUT1 VB3 net11 VDD) pmos4
M0 (net11 VB4 VDD VDD) pmos4
M5 (IIN1 net11 VSS VSS) nmos4
M4 (net18 VB1 VSS VSS) nmos4
M3 (net11 VB2 IIN1 VSS) nmos4
M2 (IOUT1 VB2 net18 VSS) nmos4
