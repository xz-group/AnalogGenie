MM14 (net025 net012 VDD VDD) pmos4
MM13 (net024 net012 VDD VDD) pmos4
MM3 (net10 VB1 net025 VDD) pmos4
MM2 (net012 VB1 net024 VDD) pmos4
MM7 (net11 net7 net14 net27) pmos4
MM6 (net16 VREF1 net14 net27) pmos4
MM5 (net14 VB2 VDD VDD) pmos4
MM12 (net29 net11 VSS VSS) nmos4
MM11 (net32 net16 VSS VSS) nmos4
MM10 (net33 net11 VSS VSS) nmos4
MM4 (net26 net16 VSS VSS) nmos4
MM1 (net10 net1003 net29 VSS) nmos4
MM0 (net012 net1003 net32 VSS) nmos4
MM9 (net11 net1003 net33 VSS) nmos4
MM8 (net16 net1003 net26 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
RR0 (net15 VSS) resistor
MM0 (VB3 VB3 VSS VSS) nmos4
MM2 (net1006 VB3 net15 VSS) nmos4
M0 (VIN1 net10 VOUT1 VOUT1) nmos4
R2 (net11 VSS) resistor
R1 (net7 VSS) resistor
R0 (VOUT1 net7) resistor
C0 (VOUT1 net11) capacitor
