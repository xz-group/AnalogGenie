M7 (VOUT2 net13 VDD VDD) pmos4
M6 (VOUT2 VCLK1 VDD VDD) pmos4
M5 (VOUT1 VCLK1 VDD VDD) pmos4
M4 (VOUT1 net39 VDD VDD) pmos4
M1 (net39 VOUT1 VDD VDD) pmos4
M0 (net13 VOUT2 VDD VDD) pmos4
M12 (net22 VCLK1 VSS VSS) nmos4
M11 (net27 VIN1 net22 net22) nmos4
M10 (net17 VIN2 net22 net22) nmos4
M9 (VOUT2 VOUT1 net27 net27) nmos4
M8 (VOUT1 VOUT2 net17 net17) nmos4
M3 (net39 VCLK2 VSS VSS) nmos4
M2 (net13 VCLK2 VSS VSS) nmos4
