M1 (VOUT1 net10 VDD VDD) pmos4
M0 (net10 net10 VDD VDD) pmos4
M3 (VOUT1 VIN2 IB1 VSS) nmos4
M2 (net10 VIN1 IB1 VSS) nmos4
R0 (net10 IB1) resistor
