C1 (VOUT1 VIN1) capacitor
C0 (VOUT1 VSS) capacitor
R1 (VOUT1 VIN1) resistor
R0 (VOUT1 VSS) resistor
