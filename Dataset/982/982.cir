M5 (net31 VB1 net33 VDD) pmos4
M4 (net29 VB1 net32 VDD) pmos4
M3 (net13 net16 VDD VDD) pmos4
M2 (net16 net16 VDD VDD) pmos4
M1 (net32 net34 VDD VDD) pmos4
M0 (net33 net34 VDD VDD) pmos4
M13 (net10 VB2 VSS VSS) nmos4
M12 (net28 VIN2 net10 VSS) nmos4
M11 (net16 VIN2 net10 VSS) nmos4
M10 (net16 VIN1 net10 VSS) nmos4
M9 (net30 VIN1 net10 VSS) nmos4
M8 (net31 net13 net30 VSS) nmos4
M7 (net13 net13 net10 VSS) nmos4
M6 (net29 net13 net28 VSS) nmos4
