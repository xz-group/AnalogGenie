M3 (VOUT2 VOUT3 VOUT4 VDD) pmos4
M2 (VOUT1 VOUT4 VOUT3 VDD) pmos4
M1 (VOUT4 VIN3 VDD VDD) pmos4
M0 (VOUT3 VIN4 VDD VDD) pmos4
M9 (VOUT2 VIN1 VSS VSS) nmos4
M8 (VOUT2 VOUT1 VSS VSS) nmos4
M7 (VOUT1 VOUT2 VSS VSS) nmos4
M6 (VOUT1 VIN2 VSS VSS) nmos4
M5 (VOUT4 VCONT1 VOUT2 VSS) nmos4
M4 (VOUT3 VCONT1 VOUT1 VSS) nmos4
