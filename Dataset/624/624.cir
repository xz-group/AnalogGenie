R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
Q18 (net36 net36 VSS 0) npn
Q17 (net37 net37 net36 0) npn
Q16 (net38 net38 net37 0) npn
Q15 (net39 net39 net38 0) npn
Q14 (net40 net40 net39 0) npn
Q13 (net41 net41 net40 0) npn
Q12 (net42 net42 net41 0) npn
Q11 (net43 net43 net42 0) npn
Q10 (VOUT2 VOUT2 net43 0) npn
Q9 (net25 net25 VSS 0) npn
Q8 (net26 net26 net25 0) npn
Q7 (net27 net27 net26 0) npn
Q6 (net28 net28 net27 0) npn
Q5 (net29 net29 net28 0) npn
Q4 (net30 net30 net29 0) npn
Q3 (net31 net31 net30 0) npn
Q2 (net32 net32 net31 0) npn
Q1 (net33 net33 net32 0) npn
Q0 (VOUT1 VOUT1 net33 0) npn
