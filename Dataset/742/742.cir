M11 (net44 VLATCH1 VSS VSS) nmos4
M10 (net35 VLATCH1 VSS VSS) nmos4
M13 (VOUT1 net35 VSS VSS) nmos4
M12 (VOUT2 net44 VSS VSS) nmos4
M9 (net44 net35 VSS VSS) nmos4
M8 (net35 net44 VSS VSS) nmos4
M4 (net039 VIN2 IB1 VSS) nmos4
M5 (net037 VIN1 IB1 VSS) nmos4
M6 (net35 net35 VSS VSS) nmos4
M7 (net44 net44 VSS VSS) nmos4
M17 (net050 VLATCH1 VDD VDD) pmos4
M16 (IB2 net050 VDD VDD) pmos4
M15 (VOUT2 net050 VDD VDD) pmos4
M14 (VOUT1 net050 VDD VDD) pmos4
M3 (net35 net039 VDD VDD) pmos4
M1 (net037 net037 VDD VDD) pmos4
M0 (net44 net037 VDD VDD) pmos4
M2 (net039 net039 VDD VDD) pmos4
R3 (VDD VOUT2) resistor
R2 (VDD VOUT1) resistor
