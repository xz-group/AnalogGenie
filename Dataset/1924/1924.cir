MM3 (VOUT1 VIN1 net16 VSS) nmos4
MM0 (net1004 VIN2 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM1 (VOUT1 net1004 VDD VDD) pmos4
MM2 (net1004 net1004 VDD VDD) pmos4
MM0 (net1004 net1005 VSS VSS) nmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
