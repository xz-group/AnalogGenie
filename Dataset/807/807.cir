M10 (VDD net72 VOUT1 VSS) nmos4
M9 (net65 VOUT1 IB1 VSS) nmos4
M8 (net68 VIN1 IB1 VSS) nmos4
M5 (net72 VB2 net70 VSS) nmos4
M4 (net61 VB2 net71 VSS) nmos4
M7 (net70 net61 VSS VSS) nmos4
M6 (net71 net61 VSS VSS) nmos4
C0 (VOUT1 VSS) capacitor
C4 (VOUT1 net72) capacitor
M1 (net65 VB3 VDD VDD) pmos4
M0 (net68 VB3 VDD VDD) pmos4
M3 (net72 VB1 net65 VDD) pmos4
M2 (net61 VB1 net68 VDD) pmos4
