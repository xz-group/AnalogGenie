M1 (VOUT2 VIN2 IB1 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
M2 (VOUT1 IB2 VDD VDD) pmos4
M3 (VOUT2 IB2 VDD VDD) pmos4
M4 (IB2 IB2 VDD VDD) pmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT2 VSS) capacitor
