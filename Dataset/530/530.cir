M4 (VCONT1 IB1 VCONT1 VSS) nmos4
M1 (VCONT1 IB1 VCONT1 VSS) nmos4
M0 (IB1 IB1 VSS VSS) nmos4
M3 (IB1 IB1 VSS VSS) nmos4
