M3 (VOUT1 net13 VDD VDD) pmos4
M2 (VOUT2 net13 VDD VDD) pmos4
M1 (net30 net30 VDD VDD) pmos4
M0 (net13 net13 VDD VDD) pmos4
M10 (IB1 net29 VSS VSS) nmos4
M9 (net15 net29 VSS VSS) nmos4
M8 (net26 net29 VSS VSS) nmos4
M7 (VOUT1 VIN2 net26 VSS) nmos4
M6 (VOUT2 VIN1 net26 VSS) nmos4
M5 (net30 net20 net15 VSS) nmos4
M4 (net13 VCM1 net15 VSS) nmos4
R1 (VOUT1 net20) resistor
R0 (VOUT2 net20) resistor
