M5 (net13 VIN1 VSS VSS) nmos4
M1 (VDD net9 VOUT1 VSS) nmos4
M0 (net9 net9 net22 VSS) nmos4
M4 (net9 VB1 VDD VDD) pmos4
M3 (VSS net13 VOUT1 VDD) pmos4
M2 (net13 net13 net22 VDD) pmos4
R0 (VOUT1 VSS) resistor
