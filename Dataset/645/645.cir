M3 (net12 VIN1 VSS VSS) nmos4
M4 (net14 net12 VSS VSS) nmos4
M5 (VOUT1 net14 VSS VSS) nmos4
M0 (net12 VIN1 VDD VDD) pmos4
M1 (net14 net12 VDD VDD) pmos4
M2 (VOUT1 net14 VDD VDD) pmos4
R1 (net12 net019) resistor
R0 (net12 VIN1) resistor
C3 (VIN1 net020) capacitor
C2 (VIN1 net12) capacitor
C0 (VIN1 VSS) capacitor
C1 (net12 VSS) capacitor
L0 (net020 net019) inductor
