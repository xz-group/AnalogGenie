M0 (VDD net015 VOUT1 VSS) nmos4
M3 (net015 VOUT1 IB1 VSS) nmos4
M1 (net013 VIN1 IB1 VSS) nmos4
M10 (net013 net013 VDD VDD) pmos4
M11 (net015 net013 VDD VDD) pmos4
R0 (VOUT1 VSS) resistor
C0 (VOUT1 VSS) capacitor
R1 (net015 VSS) capacitor
