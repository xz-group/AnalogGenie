M19 (net50 VSS net48 VSS) pmos4
M18 (net64 net41 net48 VSS) pmos4
M7 (net28 net22 net26 VDD) pmos4
M6 (net24 net21 net26 VDD) pmos4
M5 (net36 VB2 net85 VDD) pmos4
M4 (net33 VB2 net86 VDD) pmos4
M3 (net48 VB1 VDD VDD) pmos4
M2 (net85 VB1 VDD VDD) pmos4
M1 (net86 VB1 VDD VDD) pmos4
M0 (net26 VB1 VDD VDD) pmos4
M27 (net16 VCONT1 net21 VSS) nmos4
M26 (net16 VCONT2 VSS VSS) nmos4
M25 (net15 VCONT2 VSS VSS) nmos4
M24 (net15 VCONT1 net22 VSS) nmos4
M23 (net28 net64 VSS VSS) nmos4
M22 (net24 net64 VSS VSS) nmos4
M21 (net50 net50 VSS VSS) nmos4
M20 (net64 net64 VSS VSS) nmos4
M17 (VOUT2 VB6 VSS VSS) nmos4
M16 (VOUT1 VB6 VSS VSS) nmos4
M15 (net81 net24 VSS VSS) nmos4
M14 (net82 net28 VSS VSS) nmos4
M13 (net36 VB5 net82 VSS) nmos4
M12 (net33 VB5 net81 VSS) nmos4
M11 (VDD net36 VOUT2 VSS) nmos4
M10 (net84 VB4 net28 VSS) nmos4
M9 (net83 VB3 net24 VSS) nmos4
M8 (VDD net33 VOUT1 VSS) nmos4
C3 (net22 VOUT1) capacitor
C2 (net21 VOUT2) capacitor
C1 (net84 net36) capacitor
C0 (net83 net33) capacitor
R7 (VOUT1 net15) resistor
R5 (net16 VOUT2) resistor
R3 (net15 VIN1) resistor
R2 (net16 VIN2) resistor
R1 (net41 VOUT2) resistor
R0 (VOUT1 net41) resistor
