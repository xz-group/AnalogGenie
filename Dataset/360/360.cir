M15 (net013 net013 net021 VSS) nmos4
M14 (net021 net013 IB1 VSS) nmos4
M11 (VOUT2 net013 net019 VSS) nmos4
M10 (VOUT1 net013 net020 VSS) nmos4
M8 (net020 VIN1 IB1 VSS) nmos4
M9 (net019 VIN2 IB1 VSS) nmos4
R1 (net013 VDD) resistor
M13 (net014 VB1 VDD VDD) pmos4
M12 (net010 VB1 VDD VDD) pmos4
M2 (VOUT2 VB2 net014 net014) pmos4
M0 (VOUT1 VB2 net010 net010) pmos4
