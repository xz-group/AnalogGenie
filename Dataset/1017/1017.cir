M2 (VOUT1 VIN1 VDD VDD) pmos4
M1 (net12 net13 VDD VDD) pmos4
M0 (net13 net13 VDD VDD) pmos4
M6 (net12 net12 VSS VSS) nmos4
M5 (VB1 net12 VSS VSS) nmos4
M4 (VOUT1 net12 VSS VSS) nmos4
M3 (net13 VIN1 VB1 VSS) nmos4
C0 (VOUT1 VSS) capacitor
