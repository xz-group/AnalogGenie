M4 (IOUT2 net19 VSS VSS) nmos4
M3 (net21 net19 net28 VSS) nmos4
M6 (net19 net19 VSS VSS) nmos4
R0 (net28 VSS) resistor
M2 (IOUT1 net21 VDD VDD) pmos4
M1 (net21 net21 VDD VDD) pmos4
M0 (net19 net21 VDD VDD) pmos4
