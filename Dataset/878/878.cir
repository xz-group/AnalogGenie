M11 (net16 VOUT1 IB3 VDD) pmos4
M10 (net29 VIN1 IB3 VDD) pmos4
M5 (VOUT1 net42 VDD VDD) pmos4
M4 (IB1 net22 VDD VDD) pmos4
M3 (VSS IB1 net22 VDD) pmos4
M2 (VSS IB1 net42 VDD) pmos4
M1 (net42 net22 VDD VDD) pmos4
M0 (net22 net22 VDD VDD) pmos4
M15 (VOUT1 net29 VSS VSS) nmos4
M14 (IB4 net16 VSS VSS) nmos4
M13 (net29 net16 VSS VSS) nmos4
M12 (net16 net16 VSS VSS) nmos4
M9 (VDD IB4 net29 VSS) nmos4
M8 (VDD IB4 net16 VSS) nmos4
M7 (net22 VOUT1 IB2 VSS) nmos4
M6 (net42 VIN1 IB2 VSS) nmos4
C1 (VOUT1 net29) capacitor
C0 (net42 VOUT1) capacitor
