M8 (net19 VB1 VSS VSS) nmos4
M7 (net24 net27 net38 net38) nmos4
M6 (VDD VOUT2 net36 VSS) nmos4
M4 (net24 VCLK1 VOUT2 VSS) nmos4
M3 (VDD VOUT1 net37 VSS) nmos4
M2 (net12 VCLK1 VOUT1 VSS) nmos4
M0 (net12 net10 net39 net39) nmos4
M5 (VOUT2 VCLK2 net24 VDD) pmos4
M1 (VOUT1 VCLK2 net12 VDD) pmos4
R1 (net36 VSS) resistor
R0 (net37 VSS) resistor
L5 (net38 net19) inductor
L4 (VIN2 net27) inductor
L3 (VDD net24) inductor
L2 (net39 net19) inductor
L1 (VIN1 net10) inductor
L0 (VDD net12) inductor
C3 (net27 net38) capacitor
C2 (VDD VOUT2) capacitor
C1 (net10 net39) capacitor
C0 (VDD VOUT1) capacitor
