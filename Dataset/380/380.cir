M0 (net025 net018 net024 VSS) nmos4
M3 (net017 VB2 net025 VSS) nmos4
M4 (net026 net018 net016 VSS) nmos4
M2 (net018 VB2 net026 VSS) nmos4
Q1 (VSS VSS net016 0) pnp
Q0 (VSS VSS net020 0) pnp
M5 (net017 VB1 net028 VDD) pmos4
M13 (net027 net017 VDD VDD) pmos4
M1 (net028 net017 VDD VDD) pmos4
M6 (net018 VB1 net027 VDD) pmos4
R0 (net024 net020) resistor
