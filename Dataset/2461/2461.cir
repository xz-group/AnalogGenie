MM14 (net025 net012 VIN1 VIN1) pmos4
MM13 (net024 net012 VIN1 VIN1) pmos4
MM3 (net8 VB1 net025 VIN1) pmos4
MM2 (net012 VB1 net024 VIN1) pmos4
MM7 (net11 VREF1 net14 net27) pmos4
MM6 (net16 net38 net14 net27) pmos4
MM5 (net14 VB2 VIN1 VIN1) pmos4
MM12 (net29 net11 VSS VSS) nmos4
MM11 (net32 net16 VSS VSS) nmos4
MM10 (net33 net11 VSS VSS) nmos4
MM4 (net26 net16 VSS VSS) nmos4
MM1 (net8 net1003 net29 VSS) nmos4
MM0 (net012 net1003 net32 VSS) nmos4
MM9 (net11 net1003 net33 VSS) nmos4
MM8 (net16 net1003 net26 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VIN1 VIN1) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (net010 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VIN1 VIN1) pmos4
MM1 (VB3 net1006 VIN1 VIN1) pmos4
RR0 (VB3 net010) resistor
M14 (VOUT1 net36 VIN1 VIN1) pmos4
M11 (net36 net34 VIN1 VIN1) pmos4
M10 (net34 net34 VIN1 VIN1) pmos4
M6 (net26 net26 VIN1 VIN1) pmos4
M5 (net20 net20 VIN1 VIN1) pmos4
M3 (net17 net20 VIN1 VIN1) pmos4
M0 (net11 VB4 VIN1 VIN1) pmos4
M13 (net36 net11 VSS VSS) nmos4
M12 (net34 net8 VSS VSS) nmos4
M9 (net25 VB5 VSS VSS) nmos4
M8 (net20 VB6 net25 VSS) nmos4
M7 (net26 net17 net25 VSS) nmos4
M4 (net17 net8 VSS VSS) nmos4
M2 (net11 net11 VSS VSS) nmos4
M1 (net11 net8 VSS VSS) nmos4
C2 (VOUT1 net38) capacitor
C1 (VOUT1 net8) capacitor
C0 (net8 net17) capacitor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
