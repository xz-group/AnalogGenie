M5 (net31 net26 VDD VDD) pmos4
M4 (net7 net26 VDD VDD) pmos4
M3 (net26 net26 VDD VDD) pmos4
M2 (net35 net35 VDD VDD) pmos4
M1 (net36 net35 VDD VDD) pmos4
M0 (net2 net35 VDD VDD) pmos4
M16 (net36 net31 VSS VSS) nmos4
M15 (net31 net31 VSS VSS) nmos4
M14 (net20 net36 VSS VSS) nmos4
M13 (net36 net36 VSS VSS) nmos4
M12 (net20 VB1 VSS VSS) nmos4
M11 (net20 net7 VSS VSS) nmos4
M10 (net7 net7 VSS VSS) nmos4
M9 (net7 net2 VSS VSS) nmos4
M8 (net2 net2 VSS VSS) nmos4
M7 (net26 VIN1 net20 VSS) nmos4
M6 (net35 VIN2 net20 VSS) nmos4
