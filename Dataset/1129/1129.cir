R4 (net7 VSS) resistor
R3 (net14 net7) resistor
R2 (net3 net7) resistor
R1 (VDD net10) resistor
R0 (VDD net5) resistor
L1 (net10 VDD) inductor
L0 (net5 VDD) inductor
C3 (net14 net7) capacitor
C2 (net3 net7) capacitor
C1 (VDD net10) capacitor
C0 (VDD net5) capacitor
Q1 (net10 net5 net14 0) npn
Q0 (net5 net10 net3 0) npn
