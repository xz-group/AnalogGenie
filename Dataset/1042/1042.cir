M14 (net29 net29 VDD VDD) pmos4
M13 (net31 net20 VDD VDD) pmos4
M12 (net20 net20 VDD VDD) pmos4
M11 (net17 net20 VDD VDD) pmos4
M6 (net45 net29 net67 VDD) pmos4
M5 (VOUT1 net29 net66 VDD) pmos4
M4 (net66 net45 VDD VDD) pmos4
M3 (net67 net45 VDD VDD) pmos4
M2 (net60 net14 net35 VDD) pmos4
M1 (net59 VOUT1 net35 VDD) pmos4
M0 (net35 net20 VDD VDD) pmos4
M20 (IB2 VCLK2 IB3 VSS) nmos4
M19 (IB1 VCLK1 IB3 VSS) nmos4
M18 (net29 net17 VSS VSS) nmos4
M17 (net31 net31 VSS VSS) nmos4
M16 (net20 net17 net65 VSS) nmos4
M15 (net17 net17 VSS VSS) nmos4
M10 (net60 net17 VSS VSS) nmos4
M9 (net59 net17 VSS VSS) nmos4
M8 (VOUT1 net31 net60 VSS) nmos4
M7 (net45 net31 net59 VSS) nmos4
C1 (net14 VSS) capacitor
C0 (VOUT1 VSS) capacitor
R0 (net65 VSS) resistor
D5 (IB2 VOUT1) diode
D4 (VOUT1 IB1) diode
D3 (net14 IB2) diode
D2 (IB1 net14) diode
D1 (VIN1 IB2) diode
D0 (IB1 VIN1) diode
