M19 (net102 net100 VSS VSS) nmos4
M18 (VOUT2 net99 net102 VSS) nmos4
M17 (VCLK2 net115 net100 VSS) nmos4
M16 (VCLK2 VCLK3 net99 VSS) nmos4
M15 (VCLK1 VCLK3 net100 VSS) nmos4
M14 (VCLK1 net116 net99 VSS) nmos4
M13 (net104 VCLK2 VSS VSS) nmos4
M12 (net104 VCLK1 net105 VSS) nmos4
M11 (net110 VCLK1 VSS VSS) nmos4
M10 (net110 VCLK2 VOUT1 VSS) nmos4
M9 (net123 net105 IB1 VSS) nmos4
M8 (net122 VSS IB1 VSS) nmos4
M5 (VOUT1 VB2 net124 VSS) nmos4
M4 (net125 VB2 net126 VSS) nmos4
M7 (net124 net125 VSS VSS) nmos4
M6 (net126 net125 VSS VSS) nmos4
M0 (net122 VB3 VDD VDD) pmos4
M1 (net123 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net123 VDD) pmos4
M2 (net125 VB1 net122 VDD) pmos4
C3 (net105 net102) capacitor
C2 (net110 net105) capacitor
C1 (VOUT1 net104) capacitor
C0 (net105 VOUT1) capacitor
I1 (VCLK3 net115 VDD VSS) INVERTER
I0 (VCLK3 net116 VDD VSS) INVERTER
