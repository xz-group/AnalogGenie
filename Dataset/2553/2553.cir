MM14 (net025 net012 VDD VDD) pmos4
MM13 (net024 net012 VDD VDD) pmos4
MM3 (net8 VB1 net025 VDD) pmos4
MM2 (net012 VB1 net024 VDD) pmos4
MM7 (net11 net20 net14 net27) pmos4
MM6 (net16 VREF1 net14 net27) pmos4
MM5 (net14 VB2 VDD VDD) pmos4
MM12 (net29 net11 VSS VSS) nmos4
MM11 (net32 net16 VSS VSS) nmos4
MM10 (net33 net11 VSS VSS) nmos4
MM4 (net26 net16 VSS VSS) nmos4
MM1 (net8 net1003 net29 VSS) nmos4
MM0 (net012 net1003 net32 VSS) nmos4
MM9 (net11 net1003 net33 VSS) nmos4
MM8 (net16 net1003 net26 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
M3 (net21 net8 VOUT1 VDD) pmos4
M1 (VOUT1 net12 VDD VDD) pmos4
M0 (net12 VB4 VDD VDD) pmos4
M4 (net21 VB3 VSS VSS) nmos4
M2 (net12 VB5 net21 VSS) nmos4
R1 (net20 VSS) resistor
R0 (VOUT1 net20) resistor
C1 (net8 VSS) capacitor
C0 (net12 VOUT1) capacitor
