M12 (VOUT1 net3 VSS VSS) nmos4
M11 (net3 net7 VSS VSS) nmos4
M10 (net7 net7 VSS VSS) nmos4
M9 (net13 VIN1 VSS VSS) nmos4
M8 (net31 VIN1 net13 net18) nmos4
M7 (net35 net23 net13 net18) nmos4
M6 (VOUT1 net3 VDD VDD) pmos4
M5 (net3 net31 VIN1 VIN1) pmos4
M4 (net7 net35 VIN1 VIN1) pmos4
M3 (net35 net35 VIN1 VIN1) pmos4
M2 (net35 net31 VIN1 VIN1) pmos4
M1 (net31 net31 VIN1 VIN1) pmos4
M0 (net31 net35 VIN1 VIN1) pmos4
C0 (net23 VSS) capacitor
R0 (VIN1 net23) resistor
