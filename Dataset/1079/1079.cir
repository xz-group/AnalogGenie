M16 (net36 VCLK1 VDD VDD) pmos4
M15 (net43 VCLK1 VDD VDD) pmos4
M12 (VOUT2 VCLK1 VDD VDD) pmos4
M11 (VOUT2 VOUT1 VDD VDD) pmos4
M10 (VOUT1 VOUT2 VDD VDD) pmos4
M9 (VOUT1 VCLK1 VDD VDD) pmos4
M6 (net22 net15 VDD VDD) pmos4
M5 (net40 net9 VDD VDD) pmos4
M1 (net15 VCLK1 VDD VDD) pmos4
M0 (net9 VCLK1 VDD VDD) pmos4
M18 (net36 net40 VSS VSS) nmos4
M17 (net43 net22 VSS VSS) nmos4
M14 (VOUT2 VOUT1 net36 VSS) nmos4
M13 (VOUT1 VOUT2 net43 VSS) nmos4
M8 (net22 VCLK2 VSS VSS) nmos4
M7 (net40 VCLK2 VSS VSS) nmos4
M4 (net12 VCLK1 VSS VSS) nmos4
M3 (net15 VIN2 net12 VSS) nmos4
M2 (net9 VIN1 net12 VSS) nmos4
