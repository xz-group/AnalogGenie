M1 (net18 net5 VDD VDD) pmos4
M0 (net5 net18 VDD VDD) pmos4
L0 (net5 net18) inductor
C3 (IB1 VSS) capacitor
C2 (net18 net7) capacitor
C1 (net5 net13) capacitor
C0 (net18 net5) capacitor
M3 (net18 net13 IB1 VSS) nmos4
M2 (net5 net7 IB1 VSS) nmos4
R1 (VB1 net13) resistor
R0 (net7 VB1) resistor
