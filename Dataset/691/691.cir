M0 (IB1 net8 VSS VSS) nmos4
M1 (VOUT1 VB1 IB1 VDD) pmos4
R1 (VIN1 net8) resistor
R0 (VOUT1 VSS) resistor
C0 (VOUT1 VSS) capacitor
