M18 (net60 VIN1 net10 VDD) pmos4
M17 (net58 VIN2 net10 VDD) pmos4
M14 (net18 net88 net86 VDD) pmos4
M13 (VOUT1 net88 net83 VDD) pmos4
M12 (net83 net18 VDD VDD) pmos4
M11 (net86 net18 VDD VDD) pmos4
M10 (net88 VB2 net34 VDD) pmos4
M9 (VSS VB2 net37 VDD) pmos4
M6 (net53 VB1 VDD VDD) pmos4
M5 (net46 VB1 VDD VDD) pmos4
M4 (net37 VB1 VDD VDD) pmos4
M3 (net34 VB1 VDD VDD) pmos4
M2 (net30 VB1 VDD VDD) pmos4
M1 (net20 VB1 VDD VDD) pmos4
M0 (net10 VB1 VDD VDD) pmos4
M34 (net58 VB4 VSS VSS) nmos4
M33 (net51 VB4 VSS VSS) nmos4
M32 (net45 VB4 VSS VSS) nmos4
M31 (net42 VB4 VSS VSS) nmos4
M30 (net88 VB4 VSS VSS) nmos4
M29 (net63 VB4 VSS VSS) nmos4
M28 (net24 VB4 VSS VSS) nmos4
M27 (net60 VB4 VSS VSS) nmos4
M26 (VSS net51 net53 VSS) nmos4
M25 (VSS net24 net20 VSS) nmos4
M24 (VDD VB3 net51 VSS) nmos4
M23 (net46 VB3 net45 VSS) nmos4
M22 (VDD VB3 net24 VSS) nmos4
M21 (net30 VB3 net63 VSS) nmos4
M20 (net45 net58 net53 VDD) nmos4
M19 (net63 net60 net20 VDD) nmos4
M16 (net18 net30 net60 VSS) nmos4
M15 (VOUT1 net46 net58 VSS) nmos4
M8 (net34 net83 net42 VSS) nmos4
M7 (VDD net37 net42 VSS) nmos4
