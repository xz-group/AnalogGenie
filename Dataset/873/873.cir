Q5 (net23 net23 net22 0) npn
Q4 (net23 net22 net24 0) npn
Q0 (VDD net23 VOUT1 0) npn
R0 (net22 net24) resistor
R1 (VOUT1 VSS) resistor
Q3 (VSS VIN1 net24 0) pnp
Q2 (net23 VB1 VDD 0) pnp
Q1 (VSS net24 VOUT1 0) pnp
