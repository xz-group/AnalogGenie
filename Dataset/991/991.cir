M7 (VOUT1 VB2 net33 VDD) pmos4
M3 (net33 net24 VDD VDD) pmos4
M2 (net24 net24 VDD VDD) pmos4
M1 (net13 net13 VDD VDD) pmos4
M0 (net10 net13 VDD VDD) pmos4
M10 (net10 net10 VSS VSS) nmos4
M9 (net32 net10 VSS VSS) nmos4
M8 (VOUT1 VB3 net32 VSS) nmos4
M6 (net20 VB1 VSS VSS) nmos4
M5 (net24 VIN1 net20 VSS) nmos4
M4 (net13 VIN2 net20 VSS) nmos4
C0 (VOUT1 VSS) capacitor
