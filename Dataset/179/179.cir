M2 (VOUT1 net6 VDD VDD) pmos4
R0 (VB1 net7) resistor
R1 (net6 VOUT1) resistor
M0 (net11 VIN1 VSS VSS) nmos4
M1 (VOUT1 net7 net11 VSS) nmos4
C1 (VSS net6) capacitor
C0 (net7 VOUT1) capacitor
