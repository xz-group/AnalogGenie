M2 (VOUT2 VIN2 net017 VSS) nmos4
M0 (VOUT1 VIN1 net017 VSS) nmos4
M1 (net017 VB1 VSS VSS) nmos4
M4 (VOUT2 net017 VDD VDD) pmos4
M3 (VOUT1 net017 VDD VDD) pmos4
