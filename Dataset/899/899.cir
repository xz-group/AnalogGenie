M5 (VB3 IB1 net31 VDD) pmos4
M4 (VB2 IB1 net32 VDD) pmos4
M3 (IB1 IB1 VB1 VDD) pmos4
M2 (net31 VB1 VDD VDD) pmos4
M1 (net32 VB1 VDD VDD) pmos4
M0 (VB1 VB1 VDD VDD) pmos4
M8 (VB3 VB3 VSS VSS) nmos4
M7 (net30 VB2 VSS VSS) nmos4
M6 (VB2 VB2 net30 VSS) nmos4
