M7 (IOUT3 IOUT3 VSS VSS) nmos4
M6 (IOUT2 IOUT3 VSS VSS) nmos4
M5 (IOUT2 IOUT3 VSS VSS) nmos4
M4 (IOUT1 IOUT3 VSS VSS) nmos4
M3 (IOUT2 IIN1 VSS VSS) nmos4
M2 (IOUT1 IIN1 VSS VSS) nmos4
M1 (IOUT1 IIN1 VSS VSS) nmos4
M0 (IIN1 IIN1 VSS VSS) nmos4
