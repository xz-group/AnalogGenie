M1 (net042 VB1 net046 VSS) nmos4
M11 (net037 VB1 net048 VSS) nmos4
M10 (net046 VIN2 IB1 VSS) nmos4
M3 (net048 VIN1 IB1 VSS) nmos4
C3 (VOUT2 VSS) capacitor
C2 (VOUT1 VSS) capacitor
C1 (VOUT1 net048) capacitor
C0 (net046 VOUT2) capacitor
M15 (net047 VB3 VDD VDD) pmos4
M14 (net049 VB3 VDD VDD) pmos4
M13 (net042 VB2 net047 VDD) pmos4
M12 (net037 VB2 net049 VDD) pmos4
M7 (VOUT2 net042 VDD VDD) pmos4
M5 (VOUT1 net037 VDD VDD) pmos4
R1 (VOUT2 VSS) resistor
R0 (VOUT1 VSS) resistor
