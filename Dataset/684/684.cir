M5 (IB1 IB1 net052 VSS) nmos4
M4 (net052 net052 VSS VSS) nmos4
M2 (net053 net052 VSS VSS) nmos4
M0 (VOUT1 IB1 net053 VSS) nmos4
M1 (VOUT1 IB2 VDD VDD) pmos4
M3 (IB2 IB2 VDD VDD) pmos4
M6 (VDD VIN1 VDD VDD) pmos4
M7 (VDD VDD VDD VDD) pmos4
