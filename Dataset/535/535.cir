M1 (VCONT1 net1 VCONT1 VSS) nmos4
M4 (VCONT1 net6 VCONT1 VSS) nmos4
M0 (net6 net1 IB1 VDD) pmos4
M3 (net1 net6 IB1 VDD) pmos4
L1 (net6 VSS) inductor
L0 (net1 VSS) inductor
