MM8 (net9 net9 VSS VSS) nmos4
MM7 (net14 net9 VSS VSS) nmos4
MM3 (net20 VREF1 net16 VSS) nmos4
MM0 (net11 net38 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM6 (net9 net11 VDD VDD) pmos4
MM5 (net14 net20 VDD VDD) pmos4
MM1 (net20 net20 VDD VDD) pmos4
MM2 (net11 net11 VDD VDD) pmos4
MM0 (VB1 net1005 VSS VSS) nmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM3 (VB1 VB1 VDD VDD) pmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR0 (VB2 VSS) resistor
MM2 (net1006 net12 VB2 VSS) nmos4
MM0 (net12 VB2 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (net12 net1006 VDD VDD) pmos4
R3 (VOUT1 VSS) resistor
R2 (net44 VSS) resistor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
C0 (VOUT1 net44) capacitor
M7 (net30 net16 VSS VSS) nmos4
M6 (net24 net14 IB1 IB1) nmos4
M5 (VDD net17 net30 VSS) nmos4
M3 (net16 net16 VSS VSS) nmos4
M0 (VIN1 net30 VOUT1 VOUT1) nmos4
M9 (VSS IB1 net30 VSS) pmos4
M8 (net30 net24 VDD VDD) pmos4
M4 (net24 net24 VDD VDD) pmos4
M2 (net16 net14 net17 VDD) pmos4
M1 (net17 VB3 VDD VDD) pmos4
