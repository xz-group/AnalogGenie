M0 (VOUT1 VB1 VDD VDD) pmos4
M1 (VOUT1 VIN1 net1 VSS) nmos4
R3 (net1 VSS) resistor
R2 (VOUT1 net1) resistor
