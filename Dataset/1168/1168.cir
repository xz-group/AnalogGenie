M1 (net23 net20 VDD VDD) pmos4
M0 (net27 net24 VDD VDD) pmos4
M3 (net9 net30 VSS VSS) nmos4
M2 (net13 net21 VSS VSS) nmos4
C12 (net30 VSS) capacitor
C11 (net13 net30) capacitor
C10 (VSS net13) capacitor
C9 (VSS net27) capacitor
C8 (net27 net20) capacitor
C7 (net20 VSS) capacitor
C6 (net21 VSS) capacitor
C5 (net9 net21) capacitor
C4 (VSS net9) capacitor
C2 (VSS net23) capacitor
C1 (net23 net24) capacitor
C0 (net24 VSS) capacitor
L6 (net13 net27) inductor
L4 (net13 net30) inductor
L3 (net20 net27) inductor
L2 (net23 net9) inductor
L1 (net9 net21) inductor
L0 (net24 net23) inductor
