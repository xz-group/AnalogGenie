M9 (VCONT2 net28 VCONT2 VDD) pmos4
M8 (VCONT2 net10 VCONT2 VDD) pmos4
M1 (net24 VCONT1 VDD VDD) pmos4
M0 (net11 VCONT1 VDD VDD) pmos4
M11 (net28 net10 VSS VSS) nmos4
M10 (net10 net28 VSS VSS) nmos4
M7 (VOUT2 net28 VSS VSS) nmos4
M6 (VOUT1 net10 VSS VSS) nmos4
M5 (VDD net24 net28 VSS) nmos4
M4 (VDD net11 net10 VSS) nmos4
M3 (net11 net24 net28 VSS) nmos4
M2 (net24 net11 net10 VSS) nmos4
