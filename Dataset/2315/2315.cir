MM4 (net28 net38 net12 net22) pmos4
MM3 (net29 VREF1 net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB2 net25 VDD) pmos4
MM5 (net14 VB2 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 net1001 VSS VSS) nmos4
MM9 (net28 net1001 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (net14 net1003 net28 VSS) nmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB4 VB3 VSS) nmos4
MM0 (VB4 VB3 VSS VSS) nmos4
MM4 (VB3 net15 VSS VSS) nmos4
MM5 (net15 net15 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB4 net1006 VDD VDD) pmos4
MM6 (net15 net1006 VDD VDD) pmos4
R3 (VOUT1 VSS) resistor
R2 (net44 VSS) resistor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
C0 (VOUT1 net44) capacitor
M7 (net30 net16 VSS VSS) nmos4
M6 (net24 net14 IB1 IB1) nmos4
M5 (VDD net17 net30 VSS) nmos4
M3 (net16 net16 VSS VSS) nmos4
M0 (VIN1 net30 VOUT1 VOUT1) nmos4
M9 (VSS IB1 net30 VSS) pmos4
M8 (net30 net24 VDD VDD) pmos4
M4 (net24 net24 VDD VDD) pmos4
M2 (net16 net14 net17 VDD) pmos4
M1 (net17 VB5 VDD VDD) pmos4
