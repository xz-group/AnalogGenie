M2 (net1 VOUT1 VDD VDD) pmos4
M1 (VDD net1 VOUT1 VSS) nmos4
M0 (net1 VIN1 VSS VSS) nmos4
R0 (VOUT1 VSS) resistor
