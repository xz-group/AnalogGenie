M6 (VOUT1 net120 VSS VSS) nmos4
M5 (VOUT1 VOUT2 VSS VSS) nmos4
M4 (VOUT2 VOUT1 VSS VSS) nmos4
M3 (VOUT2 net97 VSS VSS) nmos4
M10 (net120 VIN1 net125 VSS) nmos4
M9 (net97 VIN2 net126 VSS) nmos4
M15 (net125 net97 net103 VSS) nmos4
M14 (net126 net120 net103 VSS) nmos4
M11 (net103 VCLK1 VSS VSS) nmos4
M21 (net120 VCLK1 VDD VDD) pmos4
M20 (net97 VCLK1 VDD VDD) pmos4
M19 (net120 VCLK2 net107 VDD) pmos4
M18 (net97 VCLK2 net117 VDD) pmos4
M0 (net104 VCLK2 VDD VDD) pmos4
M2 (VOUT1 VOUT2 net104 VDD) pmos4
M1 (VOUT2 VOUT1 net104 VDD) pmos4
M13 (net107 VCLK1 VDD VDD) pmos4
M12 (net117 VCLK1 VDD VDD) pmos4
M8 (net107 net97 VDD VDD) pmos4
M7 (net117 net120 VDD VDD) pmos4
