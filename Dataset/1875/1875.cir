MM3 (VOUT1 net17 VDD VDD) pmos4
MM2 (net17 net17 VDD VDD) pmos4
MM7 (net9 VIN2 net13 net22) pmos4
MM6 (net15 VIN1 net13 net22) pmos4
MM5 (net13 net1004 VDD VDD) pmos4
MM1 (VOUT1 net9 VSS VSS) nmos4
MM0 (net17 net15 VSS VSS) nmos4
MM9 (net9 net9 VSS VSS) nmos4
MM8 (net15 net15 VSS VSS) nmos4
MM10 (net1004 net1007 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
RR1 (net1007 net7) resistor
RR0 (VDD net7) resistor
RRF (VDD net1007) resistor
MM1 (net7 net1007 VSS VSS) nmos4
MM0 (net1007 net1007 VSS VSS) nmos4
