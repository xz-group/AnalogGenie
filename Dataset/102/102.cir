M2 (net05 IB1 VSS VSS) nmos4
M0 (IB1 IB1 VSS VSS) nmos4
M4 (IOUT1 net05 VDD VDD) pmos4
M3 (net05 net05 VDD VDD) pmos4
