M2 (VOUT1 VREF1 IB2 VDD) pmos4
M3 (net020 VIN1 IB1 VDD) pmos4
M0 (net020 VIN2 IB4 VDD) pmos4
M1 (VOUT1 VREF1 IB3 VDD) pmos4
M4 (VOUT1 VOUT1 VSS VSS) nmos4
M5 (net020 net020 VSS VSS) nmos4
R1 (IB4 IB3) resistor
R0 (IB2 IB1) resistor
