R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
M0 (net34 VIN2 IB1 VSS) nmos4
M4 (VOUT1 VCONT2 net34 VSS) nmos4
M3 (VOUT2 VCONT1 net34 VSS) nmos4
M2 (VOUT2 VCONT2 net28 VSS) nmos4
M1 (VOUT1 VCONT1 net28 VSS) nmos4
M5 (net28 VIN1 IB1 VSS) nmos4
