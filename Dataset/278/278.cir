R1 (net17 VOUT1) resistor
R0 (VIN1 net17) resistor
M1 (VOUT1 net17 VDD VDD) pmos4
M0 (VOUT1 net17 VSS VSS) nmos4
