C0 (net57 net58) capacitor
M15 (net58 VCLK1 VSS VSS) nmos4
M6 (VOUT2 VCLK2 VSS VSS) nmos4
M5 (VOUT2 VOUT1 VSS VSS) nmos4
M4 (VOUT1 VOUT2 VSS VSS) nmos4
M3 (VOUT1 VCLK2 VSS VSS) nmos4
M10 (VOUT1 VIN2 net41 VSS) nmos4
M9 (VOUT2 VIN1 net41 VSS) nmos4
M11 (net41 VCLK1 net57 VSS) nmos4
M1 (net57 VCLK2 net58 VSS) nmos4
M2 (net58 VCLK1 VDD VDD) pmos4
M12 (net55 VOUT1 VDD VDD) pmos4
M0 (net56 VOUT2 VDD VDD) pmos4
M14 (VOUT2 VOUT1 net55 VDD) pmos4
M13 (VOUT1 VOUT2 net56 VDD) pmos4
M8 (VOUT1 VCLK1 VDD VDD) pmos4
M7 (VOUT2 VCLK1 VDD VDD) pmos4
