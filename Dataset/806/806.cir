M5 (net15 VCLK1 VDD VDD) pmos4
M4 (net30 VCLK1 VDD VDD) pmos4
M3 (net30 net26 VDD VDD) pmos4
M2 (net26 net30 VDD VDD) pmos4
M1 (net26 VCLK1 VDD VDD) pmos4
M0 (net25 VCLK1 VDD VDD) pmos4
M11 (VIN1 net30 VOUT1 VSS) nmos4
M10 (net14 VCLK1 VSS VSS) nmos4
M9 (net15 VOUT1 net14 VSS) nmos4
M8 (net25 VIN1 net14 VSS) nmos4
M7 (net30 net26 net15 VSS) nmos4
M6 (net26 net30 net25 VSS) nmos4
C0 (VOUT1 VSS) capacitor
