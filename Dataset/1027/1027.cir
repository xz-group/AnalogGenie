M2 (net23 net17 VDD VDD) pmos4
M1 (net17 net16 VDD VDD) pmos4
M0 (net16 net16 VDD VDD) pmos4
Q1 (VDD net28 VOUT1 0) npn
Q0 (VDD net23 net28 0) npn
M8 (IB1 IB1 VSS VSS) nmos4
M7 (VOUT1 IB1 VSS VSS) nmos4
M6 (net23 IB1 VSS VSS) nmos4
M5 (net15 IB1 VSS VSS) nmos4
M4 (net17 VIN1 net15 VSS) nmos4
M3 (net16 VIN2 net15 VSS) nmos4
