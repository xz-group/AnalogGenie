M7 (net20 VCONT2 net24 VDD) pmos4
M5 (net14 VCONT2 net15 VDD) pmos4
M3 (net7 VCONT2 net8 VDD) pmos4
M2 (net24 net15 VDD VDD) pmos4
M1 (net15 net8 VDD VDD) pmos4
M0 (net8 net24 VDD VDD) pmos4
M11 (net20 net14 VSS VSS) nmos4
M10 (net14 net7 VSS VSS) nmos4
M9 (net7 net20 VSS VSS) nmos4
M8 (net24 VCONT1 net20 VSS) nmos4
M6 (net15 VCONT1 net14 VSS) nmos4
M4 (net8 VCONT1 net7 VSS) nmos4
