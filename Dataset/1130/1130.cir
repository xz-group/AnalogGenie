M1 (VOUT2 VOUT1 VDD VDD) pmos4
M0 (VOUT1 VOUT2 VDD VDD) pmos4
L1 (net25 VOUT2) inductor
L0 (VOUT1 net25) inductor
C1 (VB1 VOUT2) capacitor
C0 (VB1 VOUT1) capacitor
M5 (IB1 IB1 VSS VSS) nmos4
M4 (net15 IB1 VSS VSS) nmos4
M3 (VOUT2 VOUT1 net15 VSS) nmos4
M2 (VOUT1 VOUT2 net15 VSS) nmos4
