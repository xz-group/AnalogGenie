M4 (net17 IREF2 VSS VSS) nmos4
M3 (net16 IREF2 VSS VSS) nmos4
M2 (IOUT1 IREF1 net17 VSS) nmos4
M1 (IREF2 IREF1 net16 VSS) nmos4
M0 (IREF1 IREF1 VSS VSS) nmos4
