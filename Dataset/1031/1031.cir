M6 (VOUT1 net30 net42 VDD) pmos4
M5 (net35 net30 net41 VDD) pmos4
M4 (net9 net9 VDD VDD) pmos4
M3 (net20 net9 VDD VDD) pmos4
M2 (net41 net35 VDD VDD) pmos4
M1 (net42 net17 VDD VDD) pmos4
M0 (net17 net17 VDD VDD) pmos4
R1 (net20 net19) resistor
R0 (net35 net30) resistor
M14 (net11 VB1 VSS VSS) nmos4
M13 (net30 VB1 VSS VSS) nmos4
M12 (net40 net19 VSS VSS) nmos4
M11 (net39 net19 VSS VSS) nmos4
M10 (VOUT1 net20 net40 VSS) nmos4
M9 (net19 net20 net39 VSS) nmos4
M8 (net17 VIN1 net11 VSS) nmos4
M7 (net9 VIN2 net11 VSS) nmos4
C0 (VOUT1 VSS) capacitor
