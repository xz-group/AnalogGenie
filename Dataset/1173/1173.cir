Q0 (net14 net8 net10 0) npn
L10 (VCONT1 net12) inductor
L9 (net19 VCONT1) inductor
L8 (VCONT1 net13) inductor
L7 (net16 VCONT1) inductor
L6 (net10 net24) inductor
L5 (net23 net10) inductor
L4 (net14 VB3) inductor
L3 (net13 net25) inductor
L2 (net10 VB1) inductor
L1 (net8 net17) inductor
L0 (VB2 net8) inductor
C8 (net12 VSS) capacitor
C7 (net19 VSS) capacitor
C6 (net12 net23) capacitor
C5 (net19 net24) capacitor
C4 (net14 net22) capacitor
C3 (net13 VSS) capacitor
C2 (net14 net25) capacitor
C1 (net16 VSS) capacitor
C0 (net16 net17) capacitor
R0 (net22 VSS) resistor
