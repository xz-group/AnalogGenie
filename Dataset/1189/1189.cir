M0 (net38 net34 VDD VDD) pmos4
M3 (net47 net33 net38 VDD) pmos4
M2 (net33 net47 net38 VDD) pmos4
M1 (net34 net34 VDD VDD) pmos4
R0 (net34 VSS) resistor
M5 (net47 net33 net40 VSS) nmos4
M4 (net33 net47 net40 VSS) nmos4
C2 (net40 VSS) capacitor
C1 (net42 net47) capacitor
C0 (net36 net33) capacitor
L3 (net40 VSS) inductor
L2 (net47 net42) inductor
L0 (net33 net36) inductor
L1 (net36 net42) inductor
D1 (net42 VCONT1) diode
D0 (net36 VCONT1) diode
