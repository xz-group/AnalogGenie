M2 (net030 VB1 net032 VSS) nmos4
M11 (net028 VB1 net034 VSS) nmos4
M10 (net032 VIN2 IB1 VSS) nmos4
M0 (net034 VIN1 IB1 VSS) nmos4
M6 (VOUT2 VB4 VSS VSS) nmos4
M1 (VOUT1 VB4 VSS VSS) nmos4
M15 (net033 VB3 VDD VDD) pmos4
M14 (net035 VB3 VDD VDD) pmos4
M13 (net030 VB2 net033 VDD) pmos4
M12 (net028 VB2 net035 VDD) pmos4
M7 (VOUT2 net030 VDD VDD) pmos4
M3 (VOUT1 net028 VDD VDD) pmos4
