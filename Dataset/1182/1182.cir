M0 (net24 VB5 VDD VDD) pmos4
L9 (VDD VOUT2) inductor
L8 (net55 net40) inductor
L7 (VDD VOUT1) inductor
L6 (net56 net13) inductor
L5 (net48 net46) inductor
L4 (net45 net17) inductor
L3 (net24 net48) inductor
L2 (net24 net46) inductor
L1 (net24 net45) inductor
L0 (net24 net17) inductor
C7 (net34 net48) capacitor
C6 (net35 net48) capacitor
C5 (net19 net17) capacitor
C4 (net18 net17) capacitor
C3 (VCONT1 net48) capacitor
C2 (VCONT1 net17) capacitor
C1 (VCONT1 net46) capacitor
C0 (VCONT1 net45) capacitor
M12 (VOUT2 net40 VSS VSS) nmos4
M11 (net40 net48 VSS VSS) nmos4
M10 (VOUT1 net13 VSS VSS) nmos4
M9 (net13 net17 VSS VSS) nmos4
M8 (net48 net17 VSS VSS) nmos4
M7 (net17 net48 VSS VSS) nmos4
M6 (net45 net34 VSS VSS) nmos4
M5 (net46 net35 VSS VSS) nmos4
M4 (net46 net19 VSS VSS) nmos4
M3 (net45 net18 VSS VSS) nmos4
M2 (net46 net45 net22 net22) nmos4
M1 (net45 net46 net22 net22) nmos4
R5 (VDD net55) resistor
R4 (VDD net56) resistor
R3 (net34 VB4) resistor
R2 (net35 VB3) resistor
R1 (net19 VB2) resistor
R0 (net18 VB1) resistor
