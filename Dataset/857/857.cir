M5 (net02 net02 net015 VSS) nmos4
M3 (net05 net02 net016 VSS) nmos4
R0 (net016 VSS) resistor
M2 (IB1 net05 VDD VDD) pmos4
M1 (net02 net05 VDD VDD) pmos4
M0 (net05 net05 VDD VDD) pmos4
Q0 (VSS VSS net015 0) pnp
