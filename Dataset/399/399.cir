M10 (IB4 VIN2 IB2 VSS) nmos4
M1 (IB3 VIN1 IB1 VSS) nmos4
R1 (VOUT1 VSS) resistor
R0 (VOUT2 VSS) resistor
R3 (IB1 IB2) resistor
M6 (VOUT1 IB3 VDD VDD) pmos4
M5 (VOUT2 IB4 VDD VDD) pmos4
M4 (IB2 IB4 VDD VDD) pmos4
M3 (IB1 IB3 VDD VDD) pmos4
