M2 (IB1 IB1 VDD VDD) pmos4
M1 (VOUT1 IB1 VDD VDD) pmos4
M0 (VOUT1 VOUT1 VDD VDD) pmos4
M3 (VOUT1 VIN1 VSS VSS) nmos4
