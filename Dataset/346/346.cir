M3 (net013 VOUT1 IB1 VSS) nmos4
M1 (net08 VIN1 IB1 VSS) nmos4
R0 (VOUT1 VSS) resistor
C0 (net08 VOUT1) capacitor
M0 (VOUT1 net08 VDD VDD) pmos4
M9 (net013 net013 VDD VDD) pmos4
M8 (net08 net013 VDD VDD) pmos4
