M8 (VOUT1 net30 VDD VDD) pmos4
M7 (VOUT1 VOUT2 VDD VDD) pmos4
M6 (VOUT2 VOUT1 VDD VDD) pmos4
M5 (VOUT2 net17 VDD VDD) pmos4
M2 (net17 VIN2 net10 VDD) pmos4
M1 (net30 VIN1 net10 VDD) pmos4
M0 (net10 VCLK1 VDD VDD) pmos4
M12 (net33 VOUT2 VSS VSS) nmos4
M11 (net34 VOUT1 VSS VSS) nmos4
M10 (VOUT1 net30 net33 VSS) nmos4
M9 (VOUT2 net17 net34 VSS) nmos4
M4 (net17 VCLK1 VSS VSS) nmos4
M3 (net30 VCLK1 VSS VSS) nmos4
