R4 (net1 VOUT1) resistor
R3 (net1 VSS) resistor
R2 (net4 VOUT1) resistor
R1 (VDD VOUT1) resistor
R0 (VDD net4) resistor
M1 (VOUT1 net4 VSS VSS) nmos4
M0 (net4 VIN1 net1 VSS) nmos4
