M15 (net13 VCLK2 net48 VDD) pmos4
M10 (net48 VCLK1 VDD VDD) pmos4
M5 (net37 VCLK3 VDD VDD) pmos4
M4 (net40 VCLK3 VDD VDD) pmos4
M3 (net23 VCLK3 VDD VDD) pmos4
M2 (net23 net41 VDD VDD) pmos4
M1 (net41 net23 VDD VDD) pmos4
M0 (net41 VCLK3 VDD VDD) pmos4
M17 (net49 VCLK1 VSS VSS) nmos4
M16 (net13 VCLK2 net49 VSS) nmos4
M14 (net16 VCLK3 VSS VSS) nmos4
M13 (net40 net13 net16 VSS) nmos4
M12 (net37 VCM1 net16 VSS) nmos4
M11 (net25 VCLK3 VSS VSS) nmos4
M9 (net37 VIN2 net25 VSS) nmos4
M8 (net40 VIN1 net25 VSS) nmos4
M7 (net23 net41 net37 VSS) nmos4
M6 (net41 net23 net40 VSS) nmos4
C0 (net13 VSS) capacitor
