R0 (VDD VOUT1) resistor
C0 (VDD VOUT1) capacitor
M0 (VOUT1 VOUT1 VSS VSS) nmos4
L0 (VDD VOUT1) inductor
