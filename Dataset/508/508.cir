M2 (VIF2 VLO2 net8 VSS) nmos4
M3 (VIF1 VLO1 net8 VSS) nmos4
M0 (net8 VRF1 VSS VSS) nmos4
R0 (VDD VIF1) resistor
R1 (VDD VIF2) resistor
M1 (net06 VB1 VDD VDD) pmos4
C0 (net06 VSS) capacitor
L0 (net06 net8) inductor
