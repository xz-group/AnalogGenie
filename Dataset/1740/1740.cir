MM14 (net025 net012 VDD VDD) pmos4
MM13 (net024 net012 VDD VDD) pmos4
MM3 (net13 VB1 net025 VDD) pmos4
MM2 (net012 VB1 net024 VDD) pmos4
MM7 (net11 net6 net14 net27) pmos4
MM6 (net16 net10 net14 net27) pmos4
MM5 (net14 VB2 VDD VDD) pmos4
MM12 (net29 net11 VSS VSS) nmos4
MM11 (net32 net16 VSS VSS) nmos4
MM10 (net33 net11 VSS VSS) nmos4
MM4 (net26 net16 VSS VSS) nmos4
MM1 (net13 net1003 net29 VSS) nmos4
MM0 (net012 net1003 net32 VSS) nmos4
MM9 (net11 net1003 net33 VSS) nmos4
MM8 (net16 net1003 net26 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (VB3 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
M3 (net12 net13 VDD VDD) pmos4
M2 (VOUT1 net13 VDD VDD) pmos4
M1 (net6 net13 VDD VDD) pmos4
M0 (net5 net13 VDD VDD) pmos4
R1 (net10 net16) resistor
R0 (VOUT1 net10) resistor
Q3 (VSS VSS net12 0) pnp
Q2 (VSS VSS net5 0) pnp
Q1 (VSS net5 net6 0) pnp
Q0 (VSS net12 net16 0) pnp
