M26 (net3 net13 VSS VSS) nmos4
M25 (VOUT1 net3 VSS VSS) nmos4
M24 (VCONT4 net3 VSS VSS) nmos4
M23 (net13 net017 VSS VSS) nmos4
M22 (net017 net13 VSS VSS) nmos4
M21 (net017 net035 VSS VSS) nmos4
M20 (net13 net29 VSS VSS) nmos4
M19 (net29 net049 VSS VSS) nmos4
M18 (net035 net037 VSS VSS) nmos4
M17 (net037 net037 VSS VSS) nmos4
M16 (net049 net049 VSS VSS) nmos4
M15 (net047 net049 VSS VSS) nmos4
M13 (net01 VCONT5 net047 VSS) nmos4
M12 (net31 VCONT1 net047 VSS) nmos4
M11 (VOUT1 net3 VDD VDD) pmos4
M10 (net3 net13 VDD VDD) pmos4
M0 (net01 net01 VDD VDD) pmos4
M1 (net31 net01 VDD VDD) pmos4
M2 (net35 net35 VDD VDD) pmos4
M3 (net18 net35 VDD VDD) pmos4
M4 (net29 net31 VDD VDD) pmos4
M5 (net035 VCONT3 VDD VDD) pmos4
M6 (net037 net0105 net18 net18) pmos4
M7 (net035 VCONT2 net18 net18) pmos4
M8 (net13 net35 VDD VDD) pmos4
M9 (net017 net35 VDD VDD) pmos4
R3 (net0105 VSS) resistor
R2 (VCONT5 net0105) resistor
R1 (VDD VCONT5) resistor
R0 (net35 net049) resistor
