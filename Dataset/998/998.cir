M6 (VSS net24 net27 VDD) pmos4
M5 (net20 VIN1 net16 VDD) pmos4
M4 (net12 VIN2 net16 VDD) pmos4
M3 (net27 net21 VDD VDD) pmos4
M2 (net24 net21 VDD VDD) pmos4
M1 (net16 net21 VDD VDD) pmos4
M0 (net7 net21 VDD VDD) pmos4
Q0 (VDD net27 VOUT1 0) npn
M11 (VOUT1 net7 VSS VSS) nmos4
M10 (net7 net7 VSS VSS) nmos4
M9 (net24 net20 VSS VSS) nmos4
M8 (net20 net12 VSS VSS) nmos4
M7 (net12 net12 VSS VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (net24 net20) capacitor
R0 (VOUT1 VSS) resistor
