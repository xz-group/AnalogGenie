M2 (VOUT1 net22 VDD VDD) pmos4
M1 (net12 net22 VDD VDD) pmos4
M0 (IB1 net22 VDD VDD) pmos4
M7 (VOUT1 net17 VSS VSS) nmos4
M6 (net17 net9 VSS VSS) nmos4
M5 (net9 net9 VSS VSS) nmos4
M4 (net12 VIN2 net17 VDD) nmos4
M3 (net12 VIN1 net9 VDD) nmos4
C0 (VOUT1 net17) capacitor
