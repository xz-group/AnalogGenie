M2 (VIN2 VCLK1 VOUT2 VSS) nmos4
M1 (VIN1 VCLK1 VOUT1 VSS) nmos4
C1 (VOUT2 VSS) capacitor
C0 (VOUT1 VSS) capacitor
