M7 (net24 IB2 net41 VDD) pmos4
M6 (net14 IB2 net42 VDD) pmos4
M5 (net41 VIN2 net33 VDD) pmos4
M4 (IB2 IB2 net33 VDD) pmos4
M3 (net42 VIN1 net33 VDD) pmos4
M2 (VOUT1 IB1 VDD VDD) pmos4
M1 (net33 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M14 (VOUT1 net27 VSS VSS) nmos4
M13 (net27 net13 VSS VSS) nmos4
M12 (VDD net24 net27 VSS) nmos4
M11 (net40 net13 VSS VSS) nmos4
M10 (net13 net13 VSS VSS) nmos4
M9 (net24 net14 net40 VSS) nmos4
M8 (net14 net14 net13 VSS) nmos4
C0 (VOUT1 net24) capacitor
