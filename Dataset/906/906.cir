M1 (net13 net10 VDD VDD) pmos4
M0 (net10 net10 VDD VDD) pmos4
M7 (VOUT1 net10 VSS VSS) nmos4
M6 (net12 net10 VSS VSS) nmos4
M5 (net10 net10 VSS VSS) nmos4
M4 (VDD VIN1 net12 VSS) nmos4
M3 (net13 net16 net12 VSS) nmos4
M2 (VDD net13 VOUT1 VDD) nmos4
R1 (VSS net16) resistor
R0 (net16 VOUT1) resistor
