M7 (net040 VIN1 net14 VSS) nmos4
M10 (net033 VOUT1 VSS VSS) nmos4
M11 (net033 VOUT2 VSS VSS) nmos4
M6 (net037 VIN2 net14 VSS) nmos4
M12 (net14 IB1 net033 VSS) nmos4
M5 (VOUT2 VB1 net045 VSS) nmos4
M4 (VOUT1 VB1 net047 VSS) nmos4
M3 (net045 VB4 VSS VSS) nmos4
M1 (net047 VB4 VSS VSS) nmos4
M15 (IB1 IB1 net043 VSS) nmos4
M16 (net043 VREF1 VSS VSS) nmos4
M14 (net037 VB3 VDD VDD) pmos4
M13 (net040 VB3 VDD VDD) pmos4
M9 (VOUT2 VB2 net037 VDD) pmos4
M8 (VOUT1 VB2 net040 VDD) pmos4
