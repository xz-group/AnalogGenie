M12 (net16 VCLK1 VDD VDD) pmos4
M6 (net26 VCLK1 VDD VDD) pmos4
M5 (VOUT1 VCLK1 VDD VDD) pmos4
M4 (VOUT1 VOUT2 VDD VDD) pmos4
M3 (VOUT2 VOUT1 VDD VDD) pmos4
M1 (VOUT2 VCLK1 VDD VDD) pmos4
M0 (net11 VCLK1 VDD VDD) pmos4
M14 (VIN1 VCLK4 VIN2 VSS) nmos4
M13 (net16 VCLK1 VSS VSS) nmos4
M11 (net26 VCLK3 net16 VSS) nmos4
M10 (net26 VIN2 net16 VSS) nmos4
M9 (net11 VCLK2 net16 VSS) nmos4
M8 (net11 VIN1 net16 VSS) nmos4
M7 (VOUT1 VOUT2 net26 VSS) nmos4
M2 (VOUT2 VOUT1 net11 VSS) nmos4
C1 (VCLK3 VSS) capacitor
C0 (VCLK2 VSS) capacitor
