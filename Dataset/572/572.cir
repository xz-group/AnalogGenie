R2 (VDD net55) resistor
R0 (net54 net55) resistor
R1 (net47 net55) resistor
M6 (net55 net55 VSS VSS) nmos4
M5 (VOUT1 VIN2 net49 VSS) nmos4
M4 (VOUT2 VIN1 net49 VSS) nmos4
M3 (VOUT2 VIN2 net52 VSS) nmos4
M2 (VOUT1 VIN1 net52 VSS) nmos4
M1 (net52 net54 VSS VSS) nmos4
M0 (net49 net47 VSS VSS) nmos4
C3 (VOUT2 VSS) capacitor
C2 (VSS VOUT1) capacitor
C1 (VOUT2 net54) capacitor
C0 (VOUT1 net47) capacitor
L1 (VDD VOUT2) inductor
L0 (VDD VOUT1) inductor
