R1 (VIN1 VSS) resistor
R0 (VDD VOUT1) resistor
M1 (VOUT1 VB1 VIN1 VSS) nmos4
M2 (VIN1 VOUT1 VDD VDD) pmos4
