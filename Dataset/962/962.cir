M11 (VOUT6 VB2 VSS VSS) nmos4
M10 (VOUT5 VIN5 VSS VSS) nmos4
M9 (VOUT4 VOUT4 VSS VSS) nmos4
M8 (VOUT3 VIN3 VSS VSS) nmos4
M1 (VOUT1 VIN1 VSS VSS) nmos4
M0 (VDD VDD VOUT1 VSS) nmos4
M7 (VSS VSS VOUT2 VDD) pmos4
M6 (VOUT6 VIN6 VDD VDD) pmos4
M5 (VOUT5 VB1 VDD VDD) pmos4
M4 (VOUT4 VIN4 VDD VDD) pmos4
M3 (VOUT3 VOUT3 VDD VDD) pmos4
M2 (VOUT2 VIN2 VDD VDD) pmos4
