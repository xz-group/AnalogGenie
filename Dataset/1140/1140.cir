M21 (VOUT1 net29 VDD VDD) pmos4
M18 (net29 net25 VDD VDD) pmos4
M16 (net25 net21 VDD VDD) pmos4
M13 (net21 net17 net39 VDD) pmos4
M12 (net39 net17 VDD VDD) pmos4
M9 (net17 net14 VDD VDD) pmos4
M6 (net14 net11 VDD VDD) pmos4
M5 (net11 net8 VDD VDD) pmos4
M0 (net8 VIN1 VDD VDD) pmos4
M20 (VOUT1 net29 VSS VSS) nmos4
M19 (net29 net25 VSS VSS) nmos4
M17 (net25 net21 VSS VSS) nmos4
M15 (net38 net17 VSS VSS) nmos4
M14 (net21 net17 net38 VSS) nmos4
M11 (net17 VOUT2 net40 VSS) nmos4
M10 (net40 net14 VSS VSS) nmos4
M8 (net14 VOUT2 net41 VSS) nmos4
M7 (net41 net11 VSS VSS) nmos4
M4 (net42 net8 VSS VSS) nmos4
M3 (net11 VOUT2 net42 VSS) nmos4
M2 (net43 VIN1 VSS VSS) nmos4
M1 (net8 VOUT2 net43 VSS) nmos4
