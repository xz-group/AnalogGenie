M3 (VOUT1 net017 IB1 VSS) nmos4
M1 (net015 VIN1 IB1 VSS) nmos4
M10 (net015 net015 VDD VDD) pmos4
M11 (VOUT1 net015 VDD VDD) pmos4
C2 (VOUT1 net017) capacitor
C1 (net017 VSS) capacitor
