M5 (VOUT2 VIN2 net012 VSS) nmos4
M3 (VOUT1 VIN1 net012 VSS) nmos4
M0 (net012 net013 VSS VSS) nmos4
M9 (VOUT2 VB1 VDD VDD) pmos4
M8 (VOUT1 VB1 VDD VDD) pmos4
C0 (VOUT1 net013) capacitor
C1 (net013 VOUT2) capacitor
