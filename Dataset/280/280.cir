R2 (net6 VOUT1) resistor
R1 (net5 net6) resistor
R0 (VIN1 net5) resistor
C0 (net6 VSS) capacitor
M1 (VOUT1 VB1 VDD VDD) pmos4
M0 (VOUT1 net5 VSS VSS) nmos4
