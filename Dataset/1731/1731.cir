MM12 (net12 VB1 net37 VDD) pmos4
MM11 (net23 VB1 net36 VDD) pmos4
MM10 (net10 VB1 net35 VDD) pmos4
MM9 (net13 VB1 net34 VDD) pmos4
MM2 (net37 net12 VDD VDD) pmos4
MM1 (net36 net23 VDD VDD) pmos4
MM6 (net35 net12 VDD VDD) pmos4
MM5 (net34 net23 VDD VDD) pmos4
MM14 (net10 net1003 net33 VSS) nmos4
MM13 (net13 net1003 net31 VSS) nmos4
MM3 (net23 net10 net17 VSS) nmos4
MM0 (net12 net6 net17 VSS) nmos4
MM4 (net17 VB2 VSS VSS) nmos4
MM8 (net33 net10 VSS VSS) nmos4
MM7 (net31 net10 VSS VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (VB3 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
M3 (net12 net13 VDD VDD) pmos4
M2 (VOUT1 net13 VDD VDD) pmos4
M1 (net6 net13 VDD VDD) pmos4
M0 (net5 net13 VDD VDD) pmos4
R1 (net10 net16) resistor
R0 (VOUT1 net10) resistor
Q3 (VSS VSS net12 0) pnp
Q2 (VSS VSS net5 0) pnp
Q1 (VSS net5 net6 0) pnp
Q0 (VSS net12 net16 0) pnp
