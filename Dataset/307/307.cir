M1 (VDD VOUT1 IB1 VSS) nmos4
M0 (IIN1 net010 IB1 VSS) nmos4
M3 (IIN1 net010 IB2 VSS) nmos4
M10 (VDD VOUT2 IB2 VSS) nmos4
M2 (IIN1 IIN1 VDD VDD) pmos4
