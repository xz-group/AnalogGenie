R0 (VIN1 VSS) resistor
R1 (VDD VOUT1) resistor
M1 (VOUT1 VIN1 VSS VSS) nmos4
M2 (VIN1 VOUT1 VDD VDD) pmos4
