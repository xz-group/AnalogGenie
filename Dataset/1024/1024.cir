M5 (VOUT1 net15 VDD VDD) pmos4
M4 (net15 net15 VDD VDD) pmos4
M3 (net12 net15 VDD VDD) pmos4
M2 (VOUT2 net8 VDD VDD) pmos4
M1 (net21 net8 VDD VDD) pmos4
M0 (net8 net8 VDD VDD) pmos4
M6 (net8 net12 VSS VSS) nmos4
Q1 (net15 net21 net25 0) npn
Q0 (net12 net21 VSS 0) npn
R3 (VOUT2 VSS) resistor
R2 (VOUT1 VSS) resistor
R1 (net25 VSS) resistor
R0 (net21 VSS) resistor
