M4 (VOUT2 net15 net22 VDD) pmos4
M3 (VOUT1 net9 net22 VDD) pmos4
M2 (net22 VB1 VDD VDD) pmos4
M1 (net15 VB1 VDD VDD) pmos4
M0 (net9 VB1 VDD VDD) pmos4
M9 (VOUT2 VB2 VSS VSS) nmos4
M8 (VOUT1 VB2 VSS VSS) nmos4
M7 (net13 VB2 VSS VSS) nmos4
M6 (net15 VIN2 net13 VSS) nmos4
M5 (net9 VIN1 net13 VSS) nmos4
