M12 (net11 VCLK4 VSS VSS) nmos4
M6 (net42 VOUT2 net11 VIN3) nmos4
M5 (net41 VOUT1 net11 VIN3) nmos4
M4 (VOUT1 VIN2 net42 VIN3) nmos4
M3 (VOUT2 VIN1 net41 VIN3) nmos4
M2 (net23 VCLK3 VSS VSS) nmos4
M1 (VOUT2 VOUT1 net23 net23) nmos4
M0 (VOUT1 VOUT2 net23 net23) nmos4
M10 (net35 VCLK2 VSS VSS) nmos4
M9 (net21 VCLK2 VSS VSS) nmos4
M15 (VOUT2 net21 VDD VDD) pmos4
M14 (VOUT2 VCLK1 VDD VDD) pmos4
M13 (VOUT1 VCLK1 VDD VDD) pmos4
M11 (VOUT1 net35 VDD VDD) pmos4
M8 (net35 VOUT1 VDD VDD) pmos4
M7 (net21 VOUT2 VDD VDD) pmos4
