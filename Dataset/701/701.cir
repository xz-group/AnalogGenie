R5 (net14 VIN1) resistor
R4 (VIN2 net13) resistor
R2 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
M2 (VOUT1 VB1 IB1 VSS) nmos4
M1 (VOUT2 net13 IB1 VSS) nmos4
M0 (VOUT1 net14 IB1 VSS) nmos4
M5 (VOUT2 VB1 IB1 VSS) nmos4
