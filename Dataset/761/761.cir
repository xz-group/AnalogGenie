M19 (net46 VB6 VDD VDD) pmos4
M12 (VOUT1 VB5 net26 VDD) pmos4
M11 (net019 VB5 net46 VDD) pmos4
M10 (net26 VB6 VDD VDD) pmos4
M3 (net16 VB2 net11 VDD) pmos4
M2 (net05 VB2 net38 VDD) pmos4
M1 (net11 VB3 VDD VDD) pmos4
M0 (net38 VB3 VDD VDD) pmos4
M27 (VDD net29 net28 VSS) nmos4
M26 (net28 VCLK2 net31 VSS) nmos4
M25 (net28 VCLK5 net31 VSS) nmos4
M24 (net16 VCLK2 net42 VSS) nmos4
M23 (net29 VCLK4 net16 VSS) nmos4
M22 (VOUT1 VCLK3 net2 VSS) nmos4
M21 (net3 VCLK2 VSS VSS) nmos4
M20 (net2 VCLK1 VIN1 VSS) nmos4
M18 (net26 net29 IB2 VSS) nmos4
M17 (net46 VSS IB2 VSS) nmos4
M16 (net73 net019 VSS VSS) nmos4
M15 (net74 net019 VSS VSS) nmos4
M14 (VOUT1 VB4 net73 VSS) nmos4
M13 (net019 VB4 net74 VSS) nmos4
M9 (net11 net42 IB1 VSS) nmos4
M8 (net38 net3 IB1 VSS) nmos4
M7 (net75 net05 VSS VSS) nmos4
M6 (net76 net05 VSS VSS) nmos4
M5 (net16 VB1 net75 VSS) nmos4
M4 (net05 VB1 net76 VSS) nmos4
C3 (net31 net29) capacitor
C2 (VOUT1 net29) capacitor
C1 (net42 VSS) capacitor
C0 (net3 net2) capacitor
R0 (net28 VSS) resistor
