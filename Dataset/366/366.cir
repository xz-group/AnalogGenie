M6 (VOUT2 IB1 VSS VSS) nmos4
M10 (net052 VIN2 net044 VSS) nmos4
M3 (net053 VIN1 net044 VSS) nmos4
M1 (VOUT1 IB1 VSS VSS) nmos4
M8 (net044 VB4 VSS VSS) nmos4
M11 (net048 VB1 net053 VSS) nmos4
M4 (net045 VB1 net052 VSS) nmos4
M15 (net26 VB3 VDD VDD) pmos4
M14 (net8 VB3 VDD VDD) pmos4
M13 (net045 VB2 net26 net26) pmos4
M12 (net048 VB2 net8 net8) pmos4
M7 (VOUT2 net045 VDD VDD) pmos4
M5 (VOUT1 net048 VDD VDD) pmos4
R3 (VOUT1 net050) resistor
R2 (net051 VOUT2) resistor
R0 (VOUT1 IB1) resistor
R1 (IB1 VOUT2) resistor
C1 (net050 net048) capacitor
C0 (net045 net051) capacitor
