M2 (VOUT2 VIN2 net08 VSS) nmos4
M0 (VOUT1 VIN1 net08 VSS) nmos4
M1 (net08 VB1 VSS VSS) nmos4
M4 (VOUT2 net010 VDD VDD) pmos4
M3 (VOUT1 net010 VDD VDD) pmos4
R1 (VOUT2 net010) resistor
R0 (net010 VOUT1) resistor
