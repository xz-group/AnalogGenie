M2 (VOUT1 IREF1 VDD VDD) pmos4
M1 (VOUT2 IREF1 VDD VDD) pmos4
M0 (IREF1 IREF1 VDD VDD) pmos4
M7 (IREF2 IREF2 VSS VSS) nmos4
M6 (net14 IREF2 VSS VSS) nmos4
M5 (net14 IREF2 VSS VSS) nmos4
M4 (VOUT1 VIN2 net14 VSS) nmos4
M3 (VOUT2 VIN1 net14 VSS) nmos4
