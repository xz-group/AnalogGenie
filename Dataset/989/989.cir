M4 (VOUT1 IB1 VDD VDD) pmos4
M3 (net22 IB1 VDD VDD) pmos4
M2 (net29 IB1 VDD VDD) pmos4
M1 (net11 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M11 (VOUT1 net29 VSS VSS) nmos4
M10 (net29 net22 VSS VSS) nmos4
M9 (net22 net22 VSS VSS) nmos4
M8 (net21 net11 VSS VSS) nmos4
M7 (net11 net11 VSS VSS) nmos4
M6 (net22 VIN2 net21 VSS) nmos4
M5 (net29 VIN1 net21 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net29) capacitor
