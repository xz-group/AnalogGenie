M12 (net25 net25 net18 net18) pmos4
M4 (VOUT1 net18 VDD VDD) pmos4
M3 (net26 net26 VDD VDD) pmos4
M2 (net18 net26 VDD VDD) pmos4
M1 (net18 net11 VDD VDD) pmos4
M0 (net11 net11 VDD VDD) pmos4
M11 (VOUT1 VB1 VSS VSS) nmos4
M10 (net26 VB1 VSS VSS) nmos4
M9 (net25 VB1 VSS VSS) nmos4
M8 (net10 VB1 VSS VSS) nmos4
M7 (net18 VIN1 net10 VSS) nmos4
M6 (net11 VIN2 net10 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net25) capacitor
