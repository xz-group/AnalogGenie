Q2 (VSS VSS net9 0) pnp
Q1 (VSS VSS net11 0) pnp
Q0 (VSS VSS net12 0) pnp
R1 (VOUT1 net9) resistor
R0 (net10 net11) resistor
M6 (net2 net2 net12 VSS) nmos4
M3 (net8 net2 net10 VSS) nmos4
M7 (VOUT1 net8 VDD VDD) pmos4
M5 (net2 net8 VDD VDD) pmos4
M4 (net8 net8 VDD VDD) pmos4
