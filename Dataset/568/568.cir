M1 (net32 VCLK1 net20 VSS) nmos4
M5 (net29 net20 VSS VSS) nmos4
M2 (net20 LOGICB1 net35 VSS) nmos4
M7 (LOGICQ1 net29 VSS VSS) nmos4
M8 (net35 LOGICA1 VSS VSS) nmos4
M0 (net32 LOGICB1 VDD VDD) pmos4
M6 (LOGICQ1 net30 VDD VDD) pmos4
M3 (net30 net32 VDD VDD) pmos4
M4 (net29 VCLK1 net30 VDD) pmos4
M9 (net32 LOGICA1 VDD VDD) pmos4
