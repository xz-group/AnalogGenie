MM8 (net9 net9 VSS VSS) nmos4
MM7 (VOUT1 net9 VSS VSS) nmos4
MM3 (net20 net24 net16 VSS) nmos4
MM0 (net11 net26 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM6 (net9 net11 VDD VDD) pmos4
MM5 (VOUT1 net20 VDD VDD) pmos4
MM1 (net20 net20 VDD VDD) pmos4
MM2 (net11 net11 VDD VDD) pmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
Q3 (net29 net29 net24 0) pnp
Q2 (net30 net30 net31 0) pnp
Q1 (VSS VSS net30 0) pnp
Q0 (VSS VSS net29 0) pnp
R2 (VOUT1 net24) resistor
R1 (VOUT1 net26) resistor
R0 (net26 net31) resistor
