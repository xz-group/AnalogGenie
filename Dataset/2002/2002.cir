MM7 (VOUT1 VIN2 net11 net18) pmos4
MM6 (net13 VIN1 net11 net18) pmos4
MM5 (net11 net1004 VDD VDD) pmos4
MM1 (VOUT1 net17 net20 VSS) nmos4
MM0 (net13 net17 net19 VSS) nmos4
MM9 (net20 net13 VSS VSS) nmos4
MM8 (net19 net13 VSS VSS) nmos4
MM4 (net1004 VB1 VSS VSS) nmos4
MM2 (VB1 VB1 VSS VSS) nmos4
MM10 (neta net1007 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM1 (VB1 neta VDD VDD) pmos4
MM0 (neta neta VDD VDD) pmos4
RR1 (net05 VSS) resistor
RRF (VDD net1007) resistor
MM0 (net1007 net1007 net05 VSS) nmos4
