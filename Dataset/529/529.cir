M3 (net021 net023 IB1 VSS) nmos4
M0 (net023 net021 IB1 VSS) nmos4
M1 (VCONT1 net021 VCONT1 VSS) nmos4
M4 (VCONT1 net023 VCONT1 VSS) nmos4
R0 (VDD net023) resistor
R2 (VDD net021) resistor
