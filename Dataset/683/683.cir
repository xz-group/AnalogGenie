M0 (VOUT1 IB1 net047 VSS) nmos4
M2 (net047 VIN1 VSS VSS) nmos4
M4 (net046 net046 VSS VSS) nmos4
M5 (IB1 IB1 net046 VSS) nmos4
M7 (VDD VDD VDD VDD) pmos4
M6 (VDD VDD VDD VDD) pmos4
M3 (IB2 IB2 VDD VDD) pmos4
M1 (VOUT1 IB2 VDD VDD) pmos4
