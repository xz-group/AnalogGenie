MM7 (VOUT1 net12 net11 net18) pmos4
MM6 (net13 VSS net11 net18) pmos4
MM5 (net11 net1004 VDD VDD) pmos4
MM1 (VOUT1 net17 net20 VSS) nmos4
MM0 (net13 net17 net19 VSS) nmos4
MM9 (net20 net13 VSS VSS) nmos4
MM8 (net19 net13 VSS VSS) nmos4
MM2 (VB1 VB1 VSS VSS) nmos4
MM10 (net1004 net1007 VSS VSS) nmos4
MM1 (VB1 net1004 VDD VDD) pmos4
MM0 (net1004 net1004 VDD VDD) pmos4
RR1 (net05 VSS) resistor
RRF (VDD net1007) resistor
MM0 (net1007 net1007 net05 VSS) nmos4
M12 (VIN1 VCLK1 net11 VSS) nmos4
M13 (net11 VCLK2 net12 VSS) nmos4
C1 (net12 VOUT1) capacitor
C0 (net11 VSS) capacitor
