M1 (VOUT1 VOUT2 VDD VDD) pmos4
M0 (VOUT2 VOUT1 VDD VDD) pmos4
L1 (net18 VOUT1) inductor
L0 (VOUT2 net18) inductor
C1 (VCONT1 VOUT1) capacitor
C0 (VCONT1 VOUT2) capacitor
M4 (net9 VB1 VSS VSS) nmos4
M3 (VOUT1 VOUT2 net9 VSS) nmos4
M2 (VOUT2 VOUT1 net9 VSS) nmos4
