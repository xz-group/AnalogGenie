M40 (net121 VB3 VDD VDD) pmos4
M39 (net139 VB3 VDD VDD) pmos4
M38 (net123 VB4 net121 VDD) pmos4
M37 (net117 VB4 net139 VDD) pmos4
M24 (net73 net128 IB1 VDD) pmos4
M23 (net67 VSS IB1 VDD) pmos4
M4 (IB2 VB2 net132 VDD) pmos4
M3 (net147 VB2 net130 VDD) pmos4
M2 (net132 VB1 VDD VDD) pmos4
M1 (net128 VB1 VDD VDD) pmos4
M0 (net130 VB1 VDD VDD) pmos4
M46 (net116 VCLK2 IB4 VSS) nmos4
M45 (IB2 VCLK1 net114 VSS) nmos4
M44 (VCONT1 VCONT1 VSS VSS) nmos4
M43 (VDD net142 VCONT1 VSS) nmos4
M42 (net142 VCLK4 net124 VSS) nmos4
M41 (net124 VCLK3 net123 VSS) nmos4
M36 (net121 IB4 IB3 VSS) nmos4
M35 (net139 VSS IB3 VSS) nmos4
M34 (net123 VB5 net143 VSS) nmos4
M33 (net117 VB5 net144 VSS) nmos4
M32 (net143 net117 VSS VSS) nmos4
M31 (net144 net117 VSS VSS) nmos4
M29 (net116 VCLK1 VSS VSS) nmos4
M28 (net114 VCLK2 VSS VSS) nmos4
M26 (net73 net73 VSS VSS) nmos4
M25 (net67 net67 VSS VSS) nmos4
M22 (net145 net67 VSS VSS) nmos4
M21 (net146 net67 VSS VSS) nmos4
M20 (IB2 VB3 net145 VSS) nmos4
M19 (net147 VB3 net146 VSS) nmos4
M18 (net105 VCONT1 VSS VSS) nmos4
M17 (net102 VCONT1 VSS VSS) nmos4
M16 (net87 VCONT1 VSS VSS) nmos4
M15 (net79 VCONT1 VSS VSS) nmos4
M14 (net105 IB2 net102 VSS) nmos4
M13 (net102 net128 net105 VSS) nmos4
M12 (net87 VSS net79 VSS) nmos4
M11 (net79 net128 net87 VSS) nmos4
M10 (net132 IB2 net105 VSS) nmos4
M9 (net130 net128 net102 VSS) nmos4
M8 (net128 net128 net102 VSS) nmos4
M7 (net128 net128 net87 VSS) nmos4
M6 (net132 net128 net87 VSS) nmos4
M5 (net130 VSS net79 VSS) nmos4
C2 (net124 VSS) capacitor
C1 (net123 IB4) capacitor
C0 (net116 net114) capacitor
