M0 (net51 LOGICQ1 VDD VDD) pmos4
M4 (net05 net02 net52 VDD) pmos4
M6 (LOGICQ1 net52 VDD VDD) pmos4
M3 (net52 VCLK1 VDD VDD) pmos4
M8 (LOGICQ1 VCLK1 net015 VSS) nmos4
M7 (net015 net52 net05 VSS) nmos4
M5 (net05 VCLK1 VSS VSS) nmos4
M2 (net02 LOGICQ1 VSS VSS) nmos4
M1 (net51 VCLK1 net02 VSS) nmos4
