M5 (VOUT2 VB1 net025 VSS) nmos4
M4 (VOUT1 VB1 net027 VSS) nmos4
M3 (net025 VIN2 net018 VSS) nmos4
M1 (net027 VIN1 net018 VSS) nmos4
M10 (net018 IREF1 VSS VSS) nmos4
M11 (IREF1 IREF1 VSS VSS) nmos4
M9 (net026 net022 VDD VDD) pmos4
M8 (net028 net022 VDD VDD) pmos4
M7 (VOUT2 VB2 net026 VDD) pmos4
M6 (VOUT1 VB2 net028 VDD) pmos4
M12 (IREF2 net022 VDD VDD) pmos4
