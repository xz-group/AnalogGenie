M4 (VOUT1 IB4 VSS VSS) nmos4
M3 (IB4 VB1 IB2 VSS) nmos4
M2 (VDD IB3 IB2 VSS) nmos4
M1 (IB3 VIN2 IB1 VSS) nmos4
M0 (VDD VIN1 IB1 VSS) nmos4
C1 (VOUT1 IB3) capacitor
C0 (VOUT1 IB4) capacitor
R0 (VDD VOUT1) resistor
