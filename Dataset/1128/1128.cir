M4 (VB2 VOUT2 VB2 VDD) pmos4
M3 (VB2 VOUT1 VB2 VDD) pmos4
M2 (VOUT2 VOUT1 net18 net18) pmos4
M1 (VOUT1 VOUT2 net18 net18) pmos4
M0 (net18 VB1 VDD VDD) pmos4
C7 (net23 VSS) capacitor
C6 (net8 VSS) capacitor
C5 (VOUT2 net23) capacitor
C4 (VOUT1 net8) capacitor
C3 (VOUT1 VOUT2) capacitor
C2 (net16 VSS) capacitor
C1 (net33 net16) capacitor
C0 (VDD net18) capacitor
R4 (VSS net23) resistor
R3 (VSS net8) resistor
R2 (VSS net16) resistor
R1 (net34 VOUT2) resistor
R0 (VOUT1 net35) resistor
L2 (net17 net33) inductor
L1 (net17 net34) inductor
L0 (net35 net17) inductor
