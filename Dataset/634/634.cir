M19 (net8 net8 VSS VSS) nmos4
M18 (net55 net8 VSS VSS) nmos4
M17 (net38 net16 VSS VSS) nmos4
M16 (net16 net16 VSS VSS) nmos4
M13 (net37 net32 VSS VSS) nmos4
M12 (VOUT1 net59 VSS VSS) nmos4
M11 (net59 net32 VSS VSS) nmos4
M10 (net55 VIN2 net37 VSS) nmos4
M9 (net38 VIN1 net37 VSS) nmos4
M8 (net32 net32 VSS VSS) nmos4
M15 (net8 VIN2 net52 net52) pmos4
M14 (net16 VIN1 net52 net52) pmos4
M7 (net59 net55 VDD VDD) pmos4
M6 (VOUT1 net59 VDD VDD) pmos4
M5 (net55 net55 VDD VDD) pmos4
M4 (net38 net55 VDD VDD) pmos4
M3 (net4 net4 VDD VDD) pmos4
M2 (net55 net38 VDD VDD) pmos4
M1 (net38 net38 VDD VDD) pmos4
M0 (net52 net4 VDD VDD) pmos4
R0 (net4 net32) resistor
