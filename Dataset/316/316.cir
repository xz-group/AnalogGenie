M4 (VOUT2 VB2 VSS VSS) nmos4
M0 (VOUT1 VB2 VSS VSS) nmos4
M1 (net019 VIN1 IB1 VSS) nmos4
M3 (net020 VIN2 IB1 VSS) nmos4
M5 (VOUT2 net020 VDD VDD) pmos4
M2 (VOUT1 net019 VDD VDD) pmos4
M8 (net019 VB1 VDD VDD) pmos4
M9 (net020 VB1 VDD VDD) pmos4
