M4 (net13 VIN2 net8 VDD) pmos4
M3 (net5 VIN1 net8 VDD) pmos4
M2 (VOUT1 IB1 VDD VDD) pmos4
M1 (net8 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M8 (net21 VB1 net13 VSS) nmos4
M7 (VOUT1 net13 VSS VSS) nmos4
M6 (net13 net5 VSS VSS) nmos4
M5 (net5 net5 VSS VSS) nmos4
C0 (VOUT1 net21) capacitor
