Q6 (net14 VIN4 net12 0) npn
Q4 (net11 VIN3 net12 0) npn
Q3 (VOUT2 VIN1 net14 0) npn
Q2 (VOUT1 VIN2 net14 0) npn
Q1 (VOUT2 VIN2 net11 0) npn
Q0 (VOUT1 VIN1 net11 0) npn
R2 (net12 VSS) resistor
R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
