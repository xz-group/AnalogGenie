M1 (VOUT1 VB1 net5 VSS) nmos4
M0 (net5 VIN1 VSS VSS) nmos4
R1 (VOUT1 net5) resistor
R0 (VDD VOUT1) resistor
