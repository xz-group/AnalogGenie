M3 (VOUT2 LOGICA2 net013 VSS) nmos4
M2 (VOUT2 LOGICA1 net012 VSS) nmos4
M1 (VOUT1 LOGICA2 net012 VSS) nmos4
M0 (VOUT1 LOGICA1 net013 VSS) nmos4
M10 (net012 LOGICB1 IB1 VSS) nmos4
M11 (net013 LOGICB2 IB1 VSS) nmos4
R3 (VDD VOUT2) resistor
R2 (VDD VOUT1) resistor
