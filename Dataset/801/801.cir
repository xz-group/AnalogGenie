M11 (net60 VCLK2 VOUT1 VSS) nmos4
M10 (net60 VCLK1 VSS VSS) nmos4
M13 (net51 VCLK2 VSS VSS) nmos4
M15 (net51 VCLK1 VOUT1 VOUT1) nmos4
M16 (VIN1 VCLK1 net46 VSS) nmos4
M9 (net55 VOUT1 IB1 VSS) nmos4
M8 (net62 VSS IB1 VSS) nmos4
M5 (VOUT1 VB2 net64 VSS) nmos4
M4 (net50 VB2 net65 VSS) nmos4
M12 (net46 VCLK2 VSS VSS) nmos4
M7 (net64 net50 VSS VSS) nmos4
M6 (net65 net50 VSS VSS) nmos4
C3 (net60 VOUT1) capacitor
C1 (VOUT1 net51) capacitor
C2 (VOUT1 net46) capacitor
C4 (VOUT1 VOUT1) capacitor
M1 (net55 VB3 VDD VDD) pmos4
M0 (net62 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net55 VDD) pmos4
M2 (net50 VB1 net62 VDD) pmos4
