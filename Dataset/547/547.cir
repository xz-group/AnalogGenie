M1 (VCONT1 VOUT1 VCONT1 VSS) nmos4
M4 (VCONT1 VOUT2 VCONT1 VSS) nmos4
M3 (VOUT1 VOUT2 IB1 VSS) nmos4
M0 (VOUT2 VOUT1 IB1 VSS) nmos4
C0 (VDD VCONT1) capacitor
C1 (net038 VCONT1) capacitor
L0 (VDD VOUT1) inductor
L1 (VDD VOUT2) inductor
R0 (net038 VDD) resistor
