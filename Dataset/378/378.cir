M9 (net021 net021 VDD VDD) pmos4
M7 (net018 net019 VDD VDD) pmos4
M6 (net027 net019 VDD VDD) pmos4
M8 (net019 net021 VDD VDD) pmos4
Q0 (VSS VSS net028 0) pnp
Q1 (VSS VSS net018 0) pnp
M3 (net019 net018 IB1 VSS) nmos4
M5 (net021 net027 IB1 VSS) nmos4
R2 (net027 VSS) resistor
R1 (net027 net028) resistor
R0 (net018 VSS) resistor
