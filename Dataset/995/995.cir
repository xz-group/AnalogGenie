M3 (net26 VSS net17 VDD) pmos4
M2 (VOUT1 net17 VDD VDD) pmos4
M1 (net11 net11 VDD VDD) pmos4
M0 (net17 net11 VDD VDD) pmos4
M7 (VOUT1 VB2 VSS VSS) nmos4
M6 (net10 VB1 VSS VSS) nmos4
M5 (net11 VOUT1 net10 VSS) nmos4
M4 (net17 VIN1 net10 VSS) nmos4
C0 (VOUT1 net26) capacitor
