M0 (VOUT1 net11 VDD VDD) pmos4
M1 (VOUT1 net11 VSS VSS) nmos4
R2 (VOUT1 VSS) resistor
R1 (net11 VIN1) resistor
R0 (VOUT1 net11) resistor
C0 (VOUT1 VSS) capacitor
