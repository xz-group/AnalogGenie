M5 (net16 VCLK2 IB1 VSS) nmos4
M4 (net6 VCLK1 IB1 VSS) nmos4
M3 (net5 net7 net16 VSS) nmos4
M2 (net7 net5 net16 VSS) nmos4
M1 (net7 LOGICD2 net6 VSS) nmos4
M0 (net5 LOGICD1 net6 VSS) nmos4
R0 (net013 net5) resistor
R1 (net012 net7) resistor
C1 (VSS net7) capacitor
C0 (VSS net5) capacitor
L0 (VDD net013) inductor
L1 (VDD net012) inductor
