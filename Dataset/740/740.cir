M15 (VOUT1 VLATCH1 VDD VDD) pmos4
M14 (VOUT1 VOUT2 VDD VDD) pmos4
M3 (VOUT2 VLATCH1 VDD VDD) pmos4
M4 (VOUT2 VOUT1 VDD VDD) pmos4
M17 (net036 VIN2 VSS VSS) nmos4
M16 (net036 VREF2 VSS VSS) nmos4
M13 (VOUT1 VLATCH1 net032 VSS) nmos4
M12 (net032 VOUT2 net036 VSS) nmos4
M11 (net019 VIN1 VSS VSS) nmos4
M10 (net019 VREF1 VSS VSS) nmos4
M5 (VOUT2 VLATCH1 net035 VSS) nmos4
M9 (net035 VOUT1 net019 VSS) nmos4
