C1 (net4 net3) capacitor
C0 (VOUT1 VSS) capacitor
M3 (net3 VCONT2 VIN1 VSS) nmos4
M2 (VOUT1 VCONT3 net4 VSS) nmos4
M1 (VOUT1 net4 VSS VSS) nmos4
M0 (net3 VCONT1 VSS VSS) nmos4
M5 (VOUT1 net4 VDD VDD) pmos4
