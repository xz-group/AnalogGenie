M21 (net210 VCLK2 VSS VSS) nmos4
M20 (net210 VCLK1 VSS VSS) nmos4
M19 (net208 VCLK3 VSS VSS) nmos4
M18 (net216 VCLK4 net208 VSS) nmos4
M17 (VIN2 VCLK2 net215 VSS) nmos4
M14 (net215 VCLK1 VSS VSS) nmos4
M13 (net214 VCLK2 VSS VSS) nmos4
M15 (net214 VCLK1 VOUT1 VOUT1) nmos4
M16 (VIN1 VCLK2 net219 VSS) nmos4
M9 (net223 VOUT1 IB1 VSS) nmos4
M8 (net217 net216 IB1 VSS) nmos4
M5 (VOUT1 VB2 net221 VSS) nmos4
M4 (net222 VB2 net218 VSS) nmos4
M12 (net219 VCLK1 VSS VSS) nmos4
M7 (net221 net222 VSS VSS) nmos4
M6 (net218 net222 VSS VSS) nmos4
M11 (net220 VCLK4 VOUT1 VSS) nmos4
M10 (net220 VCLK3 VSS VSS) nmos4
C7 (VSS net208) capacitor
C6 (net210 net216) capacitor
C5 (net216 net215) capacitor
C1 (VOUT1 net214) capacitor
C2 (VOUT1 net219) capacitor
C4 (VOUT1 VOUT1) capacitor
C3 (net220 VOUT1) capacitor
M1 (net223 VB3 VDD VDD) pmos4
M0 (net217 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net223 VDD) pmos4
M2 (net222 VB1 net217 VDD) pmos4
