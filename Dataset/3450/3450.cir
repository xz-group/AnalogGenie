MM10 (net27 net12 VSS VSS) nmos4
MM9 (net21 net12 VSS VSS) nmos4
MM8 (net12 net1003 net27 VSS) nmos4
MM7 (VOUT1 net1003 net21 VSS) nmos4
MM3 (net32 net93 net10 VSS) nmos4
MM0 (net26 VOUT1 net10 VSS) nmos4
MM4 (net10 VB2 VSS VSS) nmos4
MM6 (net12 VB3 net26 VDD) pmos4
MM5 (VOUT1 VB3 net32 VDD) pmos4
MM1 (net32 VB1 VDD VDD) pmos4
MM2 (net26 VB1 VDD VDD) pmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM11 (net023 net024 VB4 VSS) nmos4
MM8 (net025 net010 net023 VSS) nmos4
MM9 (net024 net024 net023 VSS) nmos4
MM7 (net010 net010 net025 VSS) nmos4
MM2 (VB4 VB4 VSS VSS) nmos4
MM0 (net1006 net025 VSS VSS) nmos4
MM10 (net024 net1006 VDD VDD) pmos4
MM4 (net010 net1006 VDD VDD) pmos4
MM3 (VB4 net1006 VDD VDD) pmos4
MM1 (net1006 net1006 VDD VDD) pmos4
M10 (net97 VCLK3 VSS VSS) nmos4
M13 (net94 VCLK2 VSS VSS) nmos4
M11 (net97 VCLK4 VOUT1 VSS) nmos4
M15 (net94 VCLK1 VOUT1 VOUT1) nmos4
M16 (VIN1 VCLK2 net95 VSS) nmos4
M12 (net95 VCLK1 VSS VSS) nmos4
M17 (VIN2 VCLK2 net96 VSS) nmos4
M21 (net92 VCLK2 VSS VSS) nmos4
M20 (net92 VCLK1 VSS VSS) nmos4
M18 (net93 VCLK4 net91 VSS) nmos4
M14 (net96 VCLK1 VSS VSS) nmos4
M19 (net91 VCLK3 VSS VSS) nmos4
C3 (net97 VOUT1) capacitor
C1 (VOUT1 net94) capacitor
C2 (VOUT1 net95) capacitor
C6 (net92 net93) capacitor
C5 (net93 net96) capacitor
C7 (VSS net91) capacitor
