M5 (net29 VIN2 net12 VDD) pmos4
M4 (net34 VIN1 net12 VDD) pmos4
M3 (net28 net8 VDD VDD) pmos4
M2 (net12 net8 VDD VDD) pmos4
M1 (net36 net8 VDD VDD) pmos4
M0 (net35 net8 VDD VDD) pmos4
M11 (net35 net7 VSS VSS) nmos4
M10 (net29 net7 VSS VSS) nmos4
M9 (net11 net7 VSS VSS) nmos4
M8 (net34 net7 VSS VSS) nmos4
M7 (net28 VIN2 net11 VDD) nmos4
M6 (net36 VIN1 net11 VDD) nmos4
