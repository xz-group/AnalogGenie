M9 (VDD VDD VOUT2 VDD) nmos4
M8 (VDD VDD VOUT1 VDD) nmos4
M3 (VOUT1 VIN1 IB1 VSS) nmos4
M5 (VOUT2 VIN2 IB1 VSS) nmos4
