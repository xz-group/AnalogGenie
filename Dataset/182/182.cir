M5 (VOUT2 VB1 net36 VSS) nmos4
M4 (VOUT1 VB1 net32 VSS) nmos4
M1 (net32 VIN2 IB1 VSS) nmos4
M0 (net36 VIN1 IB1 VSS) nmos4
R1 (VOUT2 net29) resistor
R2 (net29 VOUT1) resistor
R0 (net36 net35) resistor
C1 (VDD net29) capacitor
C0 (net35 net32) capacitor
M3 (VOUT1 net29 VDD VDD) pmos4
M2 (VOUT2 net29 VDD VDD) pmos4
