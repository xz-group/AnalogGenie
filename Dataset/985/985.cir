M4 (VOUT1 VB3 net34 VDD) pmos4
M3 (net21 net11 VDD VDD) pmos4
M2 (net11 net11 VDD VDD) pmos4
M1 (net34 net18 VDD VDD) pmos4
M0 (net18 net18 VDD VDD) pmos4
M11 (net32 net21 VSS VSS) nmos4
M10 (net33 net21 VSS VSS) nmos4
M9 (VOUT1 VB2 net32 VSS) nmos4
M8 (net21 VB2 net33 VSS) nmos4
M7 (net14 VB1 VSS VSS) nmos4
M6 (net18 VIN1 net14 VSS) nmos4
M5 (net11 VIN2 net14 VSS) nmos4
C0 (VOUT1 VSS) capacitor
