M3 (net14 net7 VDD VDD) pmos4
M2 (net7 IB1 net14 VDD) pmos4
M1 (net13 net7 VDD VDD) pmos4
M0 (VOUT1 IB1 net13 VDD) pmos4
R2 (VOUT1 VSS) resistor
R0 (net7 IB1) resistor
