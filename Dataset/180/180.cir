C0 (VSS net6) capacitor
C1 (net10 net8) capacitor
M0 (net8 net6 VSS VSS) nmos4
M1 (VOUT1 VIN1 net8 VSS) nmos4
R1 (net10 VB1) resistor
R0 (net6 net8) resistor
M2 (VOUT1 net10 VDD VDD) pmos4
