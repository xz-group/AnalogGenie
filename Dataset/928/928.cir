M3 (VOUT2 VB2 net17 VDD) pmos4
M2 (VOUT1 VB2 net18 VDD) pmos4
M1 (net17 VB1 VDD VDD) pmos4
M0 (net18 VB1 VDD VDD) pmos4
M8 (net14 VCM1 VSS VSS) nmos4
M7 (net19 VIN2 net14 VSS) nmos4
M6 (net20 VIN1 net14 VSS) nmos4
M5 (VOUT2 VB3 net19 VSS) nmos4
M4 (VOUT1 VB3 net20 VSS) nmos4
