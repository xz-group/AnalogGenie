C1 (VOUT1 VIN1) capacitor
C0 (VOUT2 VSS) capacitor
R1 (VSS VOUT1) resistor
R0 (VOUT2 VIN1) resistor
