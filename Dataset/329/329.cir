M0 (net01 VB5 VSS VSS) nmos4
M11 (net030 VIN1 net01 VSS) nmos4
M10 (net031 VIN2 net01 VSS) nmos4
M1 (net034 VB4 VSS VSS) nmos4
M3 (net035 VB4 VSS VSS) nmos4
M4 (VOUT1 VB1 net034 VSS) nmos4
M5 (VOUT2 VB1 net035 VSS) nmos4
M6 (VOUT1 VB2 net030 VDD) pmos4
M7 (VOUT2 VB2 net031 VDD) pmos4
M8 (net030 VB3 VDD VDD) pmos4
M9 (net031 VB3 VDD VDD) pmos4
