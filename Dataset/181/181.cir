M1 (VOUT1 VIN2 IB1 VSS) nmos4
M0 (net45 VIN1 IB1 VSS) nmos4
C0 (net45 VOUT1) capacitor
M2 (net45 net45 VDD VDD) pmos4
M3 (VOUT1 net45 VDD VDD) pmos4
