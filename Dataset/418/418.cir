C0 (VDD VOUT1) capacitor
C1 (VOUT1 IIN1) capacitor
M0 (VOUT1 VB1 IIN1 VSS) nmos4
R1 (IIN1 VSS) resistor
R0 (VDD VOUT1) resistor
L0 (VDD VOUT1) inductor
