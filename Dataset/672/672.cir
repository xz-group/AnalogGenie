M3 (IIN1 IIN1 net6 VSS) nmos4
M2 (net6 net6 VSS VSS) nmos4
M1 (IOUT1 IIN1 net12 VSS) nmos4
M0 (net12 net6 VSS VSS) nmos4
