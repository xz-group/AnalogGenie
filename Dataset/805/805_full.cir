// Library name: Dataset
// Cell name: INVERTER
// View name: schematic
subckt INVERTER A Q VDD VSS
    M0 (Q A VDD VDD) pmos4
    M1 (Q A VSS VSS) nmos4
ends INVERTER
// End of subcircuit definition.

// Library name: Dataset
// Cell name: 804
// View name: schematic
M19 (VCLK1 net07 net08 VSS) nmos4
M18 (VCLK2 net07 net09 VSS) nmos4
M17 (VCLK2 VCLK3 net08 VSS) nmos4
M15 (VCLK1 VCLK3 net09 VSS) nmos4
M14 (net44 VCLK1 VSS VSS) nmos4
M13 (net47 VCLK2 net44 VSS) nmos4
M11 (net47 VCLK1 net45 VSS) nmos4
M10 (net67 VCLK1 VOUT1 VSS) nmos4
M16 (VIN1 net08 net41 VSS) nmos4
M9 (net61 net45 IB1 VSS) nmos4
M8 (net63 VSS IB1 VSS) nmos4
M5 (net67 VB2 net65 VSS) nmos4
M4 (net46 VB2 net66 VSS) nmos4
M12 (net41 net09 VSS VSS) nmos4
M7 (net65 net46 VSS VSS) nmos4
M6 (net66 net46 VSS VSS) nmos4
C1 (net45 net44) capacitor
C0 (net47 net67) capacitor
C2 (net44 net41) capacitor
C4 (net45 net67) capacitor
M1 (net61 VB3 VDD VDD) pmos4
M0 (net63 VB3 VDD VDD) pmos4
M3 (net67 VB1 net61 VDD) pmos4
M2 (net46 VB1 net63 VDD) pmos4
I0 (VCLK3 net07 VDD VSS) INVERTER
