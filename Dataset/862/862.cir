Q2 (VSS VSS net159 0) pnp
Q1 (VSS VSS net163 0) pnp
Q0 (VSS VSS net167 0) pnp
R2 (net155 VSS) resistor
R1 (VOUT1 net159) resistor
R0 (net164 net163) resistor
M20 (IOUT1 net168 net155 VSS) nmos4
M19 (net161 net149 VSS VSS) nmos4
M18 (net149 VB1 net161 VSS) nmos4
M14 (net160 net149 VSS VSS) nmos4
M13 (net168 VB1 net160 VSS) nmos4
M12 (net153 net155 IB1 VSS) nmos4
M11 (net156 VOUT1 IB1 VSS) nmos4
M6 (net143 net139 net165 VSS) nmos4
M4 (net139 net139 net138 VSS) nmos4
M5 (net138 net138 net167 VSS) nmos4
M3 (net165 net138 net164 VSS) nmos4
M17 (net149 VB2 net156 VDD) pmos4
M16 (net156 VB3 VDD VDD) pmos4
M15 (net153 VB3 VDD VDD) pmos4
M10 (net168 VB2 net153 VDD) pmos4
M2 (net162 net145 VDD VDD) pmos4
M1 (net166 net145 VDD VDD) pmos4
M0 (net145 net145 VDD VDD) pmos4
M9 (net143 net143 net145 VDD) pmos4
M8 (net139 net143 net166 VDD) pmos4
M7 (VOUT1 net143 net162 VDD) pmos4
