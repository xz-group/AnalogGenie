C0 (VOUT1 VSS) capacitor
M1 (VDD VOUT1 VOUT1 VSS) nmos4
M0 (VOUT1 VIN1 VSS VSS) nmos4
R0 (VDD VOUT1) resistor
