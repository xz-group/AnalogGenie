M13 (net028 VB1 VSS VSS) nmos4
M12 (net01 VB1 VSS VSS) nmos4
M5 (net040 net01 VSS VSS) nmos4
M4 (net038 net01 VSS VSS) nmos4
M3 (net039 net028 VSS VSS) nmos4
M1 (net037 net028 VSS VSS) nmos4
C2 (net038 VSS) capacitor
C0 (net039 VSS) capacitor
M9 (net028 VIN2 IB1 VDD) pmos4
M8 (net01 VIN1 IB1 VDD) pmos4
M11 (net038 net037 VDD VDD) pmos4
M10 (net037 net037 VDD VDD) pmos4
M7 (net039 net040 VDD VDD) pmos4
M6 (net040 net040 VDD VDD) pmos4
