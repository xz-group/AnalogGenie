MM4 (net28 net60 net12 net22) pmos4
MM3 (net29 VSS net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB2 net25 VDD) pmos4
MM5 (net75 VB2 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 net1001 VSS VSS) nmos4
MM9 (net28 net1001 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (net75 net1003 net28 VSS) nmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM11 (net023 net024 VB3 VSS) nmos4
MM8 (net025 net010 net023 VSS) nmos4
MM9 (net024 net024 net023 VSS) nmos4
MM7 (net010 net010 net025 VSS) nmos4
MM2 (VB3 VB3 VSS VSS) nmos4
MM0 (net1006 net025 VSS VSS) nmos4
MM10 (net024 net1006 VDD VDD) pmos4
MM4 (net010 net1006 VDD VDD) pmos4
MM3 (VB3 net1006 VDD VDD) pmos4
MM1 (net1006 net1006 VDD VDD) pmos4
M23 (net63 VCLK2 VOUT1 VSS) nmos4
M22 (net60 VCLK3 net62 VSS) nmos4
M25 (net63 VCLK3 VSS VSS) nmos4
M24 (net62 VCLK2 VSS VSS) nmos4
M15 (VOUT1 net72 net68 VSS) nmos4
M14 (net72 VOUT1 net71 VSS) nmos4
M13 (net68 net75 net67 VSS) nmos4
M12 (net71 VSS net67 VSS) nmos4
M10 (net67 VCLK1 VSS VSS) nmos4
C2 (net60 net75) capacitor
C1 (net62 net63) capacitor
C0 (net60 VOUT1) capacitor
M21 (net71 VCLK1 VDD VDD) pmos4
M20 (net68 VCLK1 VDD VDD) pmos4
M19 (VOUT1 VCLK1 VDD VDD) pmos4
M18 (VOUT1 net72 VDD VDD) pmos4
M17 (net72 VOUT1 VDD VDD) pmos4
M16 (net72 VCLK1 VDD VDD) pmos4
