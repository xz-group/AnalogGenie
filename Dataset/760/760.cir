Q23 (net0131 net0131 net0129 0) npn
Q22 (net028 net028 net0131 0) npn
Q20 (net031 net0112 net028 0) npn
Q19 (VDD net026 net096 0) npn
Q17 (net026 net026 net077 0) npn
Q16 (VDD net0126 net098 0) npn
Q13 (net034 net034 net033 0) npn
Q12 (VOUT1 VOUT1 net034 0) npn
Q10 (net032 net065 VOUT1 0) npn
Q9 (VDD net027 net054 0) npn
Q7 (net027 net027 net049 0) npn
Q6 (VDD net024 net056 0) npn
Q4 (net29 net23 net30 0) npn
Q3 (net16 net23 net31 0) npn
Q2 (net36 net6 net32 0) npn
Q1 (net6 net6 net33 0) npn
Q0 (net3 net23 net34 0) npn
M28 (net075 VCLK3 VOUT1 VSS) nmos4
M27 (VIN1 VCLK2 net075 VSS) nmos4
M26 (net0129 VB3 VSS VSS) nmos4
M24 (net077 VB2 VSS VSS) nmos4
M20 (net033 VB3 VSS VSS) nmos4
M18 (net049 VB2 VSS VSS) nmos4
M14 (net028 VCLK2 net030 VSS) nmos4
M13 (net39 VCLK1 net35 VSS) nmos4
M12 (net40 VCLK1 VSS VSS) nmos4
M11 (IB1 IB1 net29 VSS) nmos4
M8 (net35 IB1 net36 VSS) nmos4
M1 (net24 net39 net3 VSS) nmos4
M0 (net22 net40 net3 VSS) nmos4
M25 (net031 VB1 VDD VDD) pmos4
M23 (net026 net077 net098 VDD) pmos4
M22 (net099 net075 net0126 VDD) pmos4
M21 (net0126 VB1 VDD VDD) pmos4
M19 (net032 VB1 VDD VDD) pmos4
M17 (net027 net049 net056 VDD) pmos4
M16 (net057 net030 net024 VDD) pmos4
M15 (net024 VB1 VDD VDD) pmos4
M10 (net12 net12 VDD VDD) pmos4
M9 (net16 net16 net12 VDD) pmos4
M7 (VSS net16 net25 VDD) pmos4
M6 (net25 net12 VDD VDD) pmos4
M5 (net24 net12 VDD VDD) pmos4
M4 (net35 net25 net24 VDD) pmos4
M3 (net22 net12 VDD VDD) pmos4
M2 (net6 net25 net22 VDD) pmos4
R14 (net028 net095) resistor
R13 (net079 net028) resistor
R12 (net079 net0112) resistor
R11 (net096 net0129) resistor
R10 (net031 net097) resistor
R9 (VOUT1 net053) resistor
R8 (net052 VOUT1) resistor
R7 (net052 net065) resistor
R6 (net054 net033) resistor
R5 (net032 net055) resistor
R4 (net30 VSS) resistor
R3 (net31 VSS) resistor
R2 (net32 VSS) resistor
R1 (net33 VSS) resistor
R0 (net34 VSS) resistor
C2 (net030 net35) capacitor
C1 (net028 net39) capacitor
C0 (net40 VSS) capacitor
Q24 (VSS net0129 net095 0) pnp
Q21 (net079 net031 VDD 0) pnp
Q18 (VSS net026 net097 0) pnp
Q15 (VSS net026 net099 0) pnp
Q14 (VSS net033 net053 0) pnp
Q11 (net052 net032 VDD 0) pnp
Q8 (VSS net027 net055 0) pnp
Q5 (VSS net027 net057 0) pnp
