M1 (VOUT1 IB2 VDD VDD) pmos4
M0 (IB2 IB2 VDD VDD) pmos4
M4 (IB1 IB1 VSS VSS) nmos4
M3 (net16 VIN1 VSS VSS) nmos4
M2 (VOUT1 IB1 net16 VSS) nmos4
