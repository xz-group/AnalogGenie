M1 (VOUT1 net5 VDD VDD) pmos4
M0 (VOUT1 net5 VSS VSS) nmos4
C1 (net5 VOUT1) capacitor
C0 (VIN1 net5) capacitor
