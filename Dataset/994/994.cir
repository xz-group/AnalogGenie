M3 (VOUT1 net17 VDD VDD) pmos4
M2 (net17 IB1 VDD VDD) pmos4
M1 (net11 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M6 (VOUT1 net11 VSS VSS) nmos4
M5 (net17 VIN1 VSS VSS) nmos4
M4 (net11 VIN1 VSS VSS) nmos4
C1 (net17 VIN1) capacitor
C0 (net11 VIN1) capacitor
R0 (VOUT1 VSS) resistor
