M5 (net06 net06 VSS VSS) nmos4
M4 (VOUT1 VOUT1 VSS VSS) nmos4
M1 (VOUT1 VREF1 IB2 VDD) pmos4
M0 (net06 VIN2 IB2 VDD) pmos4
M3 (net06 VIN1 IB1 VDD) pmos4
M2 (VOUT1 VREF1 IB1 VDD) pmos4
