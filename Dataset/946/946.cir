Q1 (net10 net10 VSS 0) npn
Q0 (net20 net10 net17 0) npn
R1 (VREF1 net10) resistor
R0 (net17 VSS) resistor
M3 (net20 net18 net21 VDD) pmos4
M2 (VREF1 net18 net19 VDD) pmos4
M0 (net21 net20 VDD VDD) pmos4
M1 (net19 net20 VDD VDD) pmos4
