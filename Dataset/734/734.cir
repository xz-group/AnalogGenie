M7 (net7 net14 net15 VDD) pmos4
M6 (net7 net24 net8 VDD) pmos4
M5 (VREF1 net15 VDD VDD) pmos4
M4 (net24 net15 VDD VDD) pmos4
M3 (net14 net15 VDD VDD) pmos4
M2 (net10 net15 VDD VDD) pmos4
M1 (net15 net8 VDD VDD) pmos4
M0 (net8 net8 VDD VDD) pmos4
M10 (net15 VCONT1 VSS VSS) nmos4
M9 (net10 net10 VSS VSS) nmos4
M8 (net7 net10 VSS VSS) nmos4
C1 (net14 VSS) capacitor
C0 (VDD net15) capacitor
R3 (VREF1 VSS) resistor
R2 (net24 VSS) resistor
R1 (net24 net21) resistor
R0 (net14 VSS) resistor
D3 (net21 VSS) diode
D2 (net21 VSS) diode
D1 (net21 VSS) diode
D0 (net14 VSS) diode
