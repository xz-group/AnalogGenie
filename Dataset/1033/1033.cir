M4 (VOUT1 VIN2 net11 VDD) pmos4
M2 (net7 VIN1 net11 VDD) pmos4
M0 (net11 net7 VDD VDD) pmos4
M5 (VOUT1 VIN2 net10 VSS) nmos4
M3 (net7 VIN1 net10 VSS) nmos4
M1 (net10 net7 VSS VSS) nmos4
C0 (VOUT1 VSS) capacitor
