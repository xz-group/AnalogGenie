M5 (net36 net12 net27 VDD) pmos4
M4 (VOUT1 net27 VDD VDD) pmos4
M3 (net12 net12 net13 VDD) pmos4
M2 (net13 net13 VDD VDD) pmos4
M1 (net27 net23 VDD VDD) pmos4
M0 (net23 net23 VDD VDD) pmos4
C2 (VOUT1 VSS) capacitor
C1 (net23 VSS) capacitor
C0 (VOUT1 net36) capacitor
M11 (VOUT1 IB1 VSS VSS) nmos4
M10 (IB1 IB1 VSS VSS) nmos4
M9 (net12 IB1 VSS VSS) nmos4
M8 (net21 IB1 VSS VSS) nmos4
M7 (net27 VIN1 net21 VSS) nmos4
M6 (net23 VIN2 net21 VSS) nmos4
