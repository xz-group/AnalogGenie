M4 (net05 net05 VSS VSS) nmos4
M1 (net017 net05 VSS VSS) nmos4
R0 (VDD net010) resistor
M13 (net05 net017 net010 net010) pmos4
M3 (net017 net017 VDD VDD) pmos4
