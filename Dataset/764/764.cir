M6 (net24 VB1 net42 VDD) pmos4
M5 (net34 VB1 net43 VDD) pmos4
M4 (net15 VB1 net44 VDD) pmos4
M3 (net42 net16 VDD VDD) pmos4
M2 (net43 net16 VDD VDD) pmos4
M1 (net44 net16 VDD VDD) pmos4
M0 (net30 net16 VDD VDD) pmos4
Q3 (net24 VHOLD1 IB1 0) npn
Q2 (net34 VTRACK1 IB1 0) npn
Q1 (net15 VIN1 net24 0) npn
Q0 (net15 VIN1 net34 0) npn
D3 (VOUT2 net24) diode
D2 (net24 VOUT1) diode
D1 (net34 VOUT2) diode
D0 (VOUT1 net34) diode
C1 (VOUT2 VSS) capacitor
C0 (VOUT1 VSS) capacitor
M7 (VDD net15 net30 VSS) nmos4
R0 (net30 VSS) resistor
