MM1 (net16 net20 VDD VDD) pmos4
MM2 (net12 net20 VDD VDD) pmos4
MM9 (net9 net12 VDD VDD) pmos4
MM5 (VOUT1 net16 VDD VDD) pmos4
MM7 (net9 net9 VSS VSS) nmos4
MM3 (net16 VSS net15 VSS) nmos4
MM0 (net12 net12 net15 VSS) nmos4
MM4 (net15 net1005 VSS VSS) nmos4
MM6 (VOUT1 net9 VSS VSS) nmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
MM2 (net1006 VB1 VSS VSS) nmos4
MM0 (net010 VB1 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB1 net1006 VDD VDD) pmos4
RR0 (VB1 net010) resistor
M12 (VIN1 VCLK1 net11 VSS) nmos4
M13 (net11 VCLK2 net12 VSS) nmos4
C1 (net12 VOUT1) capacitor
C0 (net11 VSS) capacitor
