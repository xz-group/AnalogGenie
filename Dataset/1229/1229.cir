MM4 (net28 net35 net12 net22) pmos4
MM3 (net29 VREF1 net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB2 net25 VDD) pmos4
MM5 (net38 VB2 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 net1001 VSS VSS) nmos4
MM9 (net28 net1001 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (net38 net1003 net28 VSS) nmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 VDD VDD) pmos4
M16 (net33 net18 net014 net014) pmos4
M15 (net18 net18 net014 net014) pmos4
M11 (net27 net38 net014 net014) pmos4
M4 (net20 VCONT5 VOUT1 VOUT1) pmos4
M2 (net15 VCONT3 VIN1 VIN1) pmos4
M1 (net33 VCONT2 VIN1 VIN1) pmos4
M0 (net014 VCONT1 VIN1 VIN1) pmos4
C2 (VOUT1 VSS) capacitor
C1 (VOUT1 net36) capacitor
C0 (net33 net15) capacitor
L0 (net33 net20) inductor
M14 (net27 VB3 VSS VSS) nmos4
M13 (net18 net27 VSS VSS) nmos4
M12 (net27 net27 VSS VSS) nmos4
M3 (net20 VCONT4 VSS VSS) nmos4
R1 (net35 VSS) resistor
R0 (VOUT1 net35) resistor
D0 (net36 net15) diode
