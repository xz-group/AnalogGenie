M0 (IIN1 VOUT1 VSS VSS) nmos4
M2 (net03 IIN1 VSS VSS) nmos4
R2 (VSS VOUT1) resistor
R0 (net03 VDD) resistor
R1 (IIN1 VDD) resistor
M1 (VOUT1 net03 VDD VDD) pmos4
