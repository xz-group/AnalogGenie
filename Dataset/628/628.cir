M17 (VOUT1 net24 VSS VSS) nmos4
M16 (net19 net19 VSS VSS) nmos4
M15 (net24 net19 VSS VSS) nmos4
M14 (net29 VIN1 net16 VSS) nmos4
M13 (IB1 VIN2 net16 VSS) nmos4
M9 (net37 net11 VSS VSS) nmos4
M12 (net11 net11 net38 VSS) nmos4
M11 (net16 net11 net37 VSS) nmos4
M10 (net38 net11 VSS VSS) nmos4
M8 (VOUT1 IB1 VDD VDD) pmos4
M7 (net24 IB1 net29 VDD) pmos4
M6 (net19 IB1 net35 VDD) pmos4
M5 (net29 IB1 VDD VDD) pmos4
M4 (net35 IB1 VDD VDD) pmos4
M3 (net11 IB1 net39 VDD) pmos4
M2 (IB1 IB1 net40 VDD) pmos4
M1 (net39 IB1 VDD VDD) pmos4
M0 (net40 IB1 VDD VDD) pmos4
C0 (VOUT1 net24) capacitor
