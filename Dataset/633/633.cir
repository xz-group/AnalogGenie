M12 (VOUT1 net21 VSS VSS) nmos4
M11 (net21 IB1 VSS VSS) nmos4
M10 (IB1 IB1 VSS VSS) nmos4
M9 (net13 IB1 VSS VSS) nmos4
M8 (net18 net19 net13 VSS) nmos4
M7 (net10 VIN1 net13 VSS) nmos4
M6 (VOUT1 net21 VDD VDD) pmos4
M5 (net21 net18 VDD VDD) pmos4
M4 (net19 net18 VDD VDD) pmos4
M3 (net10 net18 VDD VDD) pmos4
M2 (net18 net18 VDD VDD) pmos4
M1 (net18 net10 VDD VDD) pmos4
M0 (net10 net10 VDD VDD) pmos4
R0 (net19 VB1) resistor
