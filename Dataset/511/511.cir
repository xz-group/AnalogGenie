M6 (VOUT1 VLO1 VBB2 VSS) nmos4
M7 (VOUT1 VLO2 VBB1 VSS) nmos4
M8 (VOUT2 VLO1 VBB1 VSS) nmos4
M9 (VOUT2 VLO2 VBB2 VSS) nmos4
