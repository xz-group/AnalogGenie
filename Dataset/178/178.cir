C0 (VOUT1 net6) capacitor
M1 (VOUT1 VB1 net6 VSS) nmos4
M0 (net6 VIN1 VSS VSS) nmos4
M2 (VOUT1 VB1 VDD VDD) pmos4
