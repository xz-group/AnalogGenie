M1 (VOUT1 net12 VDD VDD) pmos4
M0 (net12 net12 VDD VDD) pmos4
M5 (VIN1 net7 VSS VSS) nmos4
M4 (net7 net7 VSS VSS) nmos4
M3 (VOUT1 net12 VIN1 VSS) nmos4
M2 (net12 net12 net7 VSS) nmos4
