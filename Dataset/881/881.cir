M27 (VOUT1 net14 VDD VDD) pmos4
M18 (net55 VIN1 IB2 VDD) pmos4
M17 (net24 VOUT1 IB2 VDD) pmos4
M16 (net43 VB3 net73 net38) pmos4
M15 (net46 VB3 net47 net38) pmos4
M14 (net73 net43 net38 net38) pmos4
M13 (net47 net43 net38 net38) pmos4
M6 (net41 net14 VDD VDD) pmos4
M5 (net14 VB1 VDD VDD) pmos4
M4 (net14 net14 VDD VDD) pmos4
M3 (net33 VB1 VDD VDD) pmos4
M2 (net33 net33 VDD VDD) pmos4
M1 (net52 net33 VDD VDD) pmos4
M0 (VOUT1 net52 VDD VDD) pmos4
M26 (VOUT1 net55 VSS VSS) nmos4
M25 (net55 VB4 net19 net19) nmos4
M24 (net55 net55 net19 net19) nmos4
M23 (net24 net24 net19 net19) nmos4
M22 (net24 VB4 net19 net19) nmos4
M21 (VOUT1 net46 net19 net19) nmos4
M20 (net46 net24 net19 net19) nmos4
M19 (net43 net55 net19 net19) nmos4
M12 (net33 VOUT1 IB1 VSS) nmos4
M11 (net14 VIN1 IB1 VSS) nmos4
M10 (net51 net41 VSS VSS) nmos4
M9 (net74 net41 VSS VSS) nmos4
M8 (net52 VB2 net51 VSS) nmos4
M7 (net41 VB2 net74 VSS) nmos4
C3 (net55 net70) capacitor
C2 (net71 net14) capacitor
C1 (VOUT1 net47) capacitor
C0 (VOUT1 net51) capacitor
R1 (net70 VOUT1) resistor
R0 (net71 VOUT1) resistor
