M3 (net14 VB1 net15 VDD) pmos4
M2 (VOUT1 VIN1 VDD VDD) pmos4
M1 (net15 VIN1 VDD VDD) pmos4
M0 (net7 VIN1 VDD VDD) pmos4
M6 (net7 net7 VSS VSS) nmos4
M5 (net14 net7 VSS VSS) nmos4
M4 (VOUT1 net14 VSS VSS) nmos4
C0 (VOUT1 net15) capacitor
