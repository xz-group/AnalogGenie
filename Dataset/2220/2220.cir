MM4 (net28 net7 net12 net22) pmos4
MM3 (net29 VREF1 net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB2 net25 VDD) pmos4
MM5 (net10 VB2 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 net1001 VSS VSS) nmos4
MM9 (net28 net1001 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (net10 net1003 net28 VSS) nmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
M0 (VIN1 net10 VOUT1 VOUT1) nmos4
R2 (net11 VSS) resistor
R1 (net7 VSS) resistor
R0 (VOUT1 net7) resistor
C0 (VOUT1 net11) capacitor
