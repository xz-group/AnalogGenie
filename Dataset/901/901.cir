Q6 (VSS VIN1 net14 0) pnp
Q5 (VSS VIN2 net6 0) pnp
Q4 (net18 net14 net10 0) pnp
Q3 (net8 net6 net10 0) pnp
Q2 (net14 VB1 VDD 0) pnp
Q1 (net10 VB1 VDD 0) pnp
Q0 (net6 VB1 VDD 0) pnp
Q8 (net18 net8 VSS 0) npn
Q7 (net8 net8 VSS 0) npn
