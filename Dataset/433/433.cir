M7 (VOUT1 VIN1 net25 VSS) nmos4
M6 (VOUT2 VIN2 net25 VSS) nmos4
M5 (VOUT2 net15 net18 VSS) nmos4
M4 (VOUT1 net13 net18 VSS) nmos4
M3 (net18 VCONT1 IB2 VSS) nmos4
M2 (net25 VCONT2 IB2 VSS) nmos4
M1 (net15 VIN1 IB1 VSS) nmos4
M0 (net13 VIN2 IB1 VSS) nmos4
R3 (VDD VOUT2) resistor
R2 (VDD VOUT1) resistor
R1 (VDD net15) resistor
R0 (VDD net13) resistor
