M4 (VOUT1 VIN2 IB2 VDD) pmos4
M3 (VOUT2 VIN1 IB2 VDD) pmos4
M7 (net048 VIN2 IB1 VDD) pmos4
M5 (VOUT2 VB1 VDD VDD) pmos4
M6 (net046 VIN1 IB1 VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M10 (VOUT2 net048 VSS VSS) nmos4
M1 (net048 VB1 VSS VSS) nmos4
M8 (net046 VB1 VSS VSS) nmos4
M2 (VOUT1 net046 VSS VSS) nmos4
