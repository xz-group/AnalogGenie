M2 (net22 net19 net20 VDD) pmos4
M1 (net19 net22 net20 VDD) pmos4
M0 (net20 VB2 VDD VDD) pmos4
R3 (VB1 net11) resistor
R2 (net12 VB1) resistor
R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
M8 (net22 net11 VSS VSS) nmos4
M7 (net19 net12 VSS VSS) nmos4
M6 (VOUT2 VLO1 net22 VSS) nmos4
M5 (VOUT1 VLO2 net22 VSS) nmos4
M4 (VOUT2 VLO2 net19 VSS) nmos4
M3 (VOUT1 VLO1 net19 VSS) nmos4
C1 (net11 VRF2) capacitor
C0 (net12 VRF1) capacitor
