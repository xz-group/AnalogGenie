M11 (IB2 IB2 net42 VDD) pmos4
M10 (VSS IB2 net34 VDD) pmos4
M9 (net17 IB1 net32 VDD) pmos4
M8 (IB1 IB1 net43 VDD) pmos4
M3 (VOUT1 net24 net45 VDD) pmos4
M2 (net24 net24 net23 VDD) pmos4
M1 (net45 net23 VDD VDD) pmos4
M0 (net23 net23 VDD VDD) pmos4
M15 (net44 net16 VSS VSS) nmos4
M14 (net16 net16 VSS VSS) nmos4
M13 (VOUT1 net17 net44 VSS) nmos4
M12 (net17 net17 net16 VSS) nmos4
M7 (VDD VIN2 net42 VDD) nmos4
M6 (VDD VIN2 net32 VDD) nmos4
M5 (net24 VIN1 net34 VSS) nmos4
M4 (VDD VIN1 net43 VSS) nmos4
