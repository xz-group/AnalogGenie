L2 (VIN1 net013) inductor
L1 (net012 VSS) inductor
L0 (VDD VOUT1) inductor
M0 (net011 net013 net012 VSS) nmos4
M2 (VOUT1 VDD net011 VSS) nmos4
M1 (VOUT1 VB1 VDD VDD) pmos4
