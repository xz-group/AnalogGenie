M6 (net44 VCM1 net31 VDD) pmos4
M5 (net28 VOUT1 net31 VDD) pmos4
M4 (net22 VB2 net36 VDD) pmos4
M3 (net16 VB2 net35 VDD) pmos4
M2 (net31 VB1 VDD VDD) pmos4
M1 (net36 VB1 VDD VDD) pmos4
M0 (net35 VB1 VDD VDD) pmos4
R1 (net22 VOUT1) resistor
R0 (VOUT1 net16) resistor
M15 (net12 VB3 VSS VSS) nmos4
M14 (net35 VIN1 net12 VSS) nmos4
M13 (net36 VIN2 net12 VSS) nmos4
M12 (net44 net28 VSS VSS) nmos4
M11 (net28 net28 VSS VSS) nmos4
M10 (net42 net44 VSS VSS) nmos4
M9 (net43 net44 VSS VSS) nmos4
M8 (net16 VB4 net43 VSS) nmos4
M7 (net22 VB4 net42 VSS) nmos4
C1 (net16 net44) capacitor
C0 (net22 net44) capacitor
