MM13 (VOUT1 net38 VSS VSS) nmos4
MM9 (net38 net35 VSS VSS) nmos4
MM8 (net35 net35 VSS VSS) nmos4
MM12 (VOUT1 net1004 VDD VDD) pmos4
MM11 (net33 net1004 VDD VDD) pmos4
MM10 (net38 VIN2 net33 net39) pmos4
MM7 (net35 VIN1 net33 net39) pmos4
CC2 (VOUT1 net38) capacitor
MM0 (net1004 VB1 VSS VSS) nmos4
MM8 (VB1 VB1 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM10 (VB1 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
