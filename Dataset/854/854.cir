M5 (net02 net07 VSS VSS) nmos4
M4 (IB1 net07 VSS VSS) nmos4
M3 (net05 net02 net07 VSS) nmos4
R0 (net07 VSS) resistor
M2 (IB2 net05 VDD VDD) pmos4
M1 (net02 net05 VDD VDD) pmos4
M0 (net05 net05 VDD VDD) pmos4
