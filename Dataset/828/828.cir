Q1 (VOUT1 VIN2 net4 0) npn
Q0 (VOUT2 VIN1 net5 0) npn
R3 (net4 VSS) resistor
R2 (net5 VSS) resistor
R1 (VDD VOUT1) resistor
R0 (VDD VOUT2) resistor
