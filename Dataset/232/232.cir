C0 (net06 VSS) capacitor
C2 (VOUT1 net06) capacitor
M0 (net05 net06 VSS VSS) nmos4
M1 (VOUT1 VIN1 net05 VSS) nmos4
R1 (VSS net05) resistor
R0 (VOUT1 VDD) resistor
