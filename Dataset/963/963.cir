M13 (VOUT5 net52 net63 VDD) pmos4
M12 (net52 net52 net53 VDD) pmos4
M11 (VOUT4 net44 net64 VDD) pmos4
M10 (net44 net44 net45 VDD) pmos4
M9 (net63 net53 VDD VDD) pmos4
M8 (net53 net53 VDD VDD) pmos4
M7 (net64 net45 VDD VDD) pmos4
M6 (net45 net45 VDD VDD) pmos4
M5 (VOUT3 net34 VDD VDD) pmos4
M4 (net34 net34 VDD VDD) pmos4
M3 (VOUT2 VB1 VDD VDD) pmos4
M2 (net65 VB1 VDD VDD) pmos4
M1 (VOUT1 VOUT1 VDD VDD) pmos4
M0 (net20 net20 VDD VDD) pmos4
M25 (net61 VIN10 net51 VSS) nmos4
M24 (net62 VIN9 net51 VSS) nmos4
M23 (VOUT4 VIN8 net43 VSS) nmos4
M22 (net44 VIN7 net43 VSS) nmos4
M21 (VOUT3 VIN6 net35 VSS) nmos4
M20 (net34 VIN5 net35 VSS) nmos4
M19 (VOUT2 VIN4 net29 VSS) nmos4
M18 (net65 VIN3 net29 VSS) nmos4
M17 (VOUT1 VIN2 net23 VSS) nmos4
M16 (net20 VIN1 net23 VSS) nmos4
M15 (VOUT5 VB2 net61 VSS) nmos4
M14 (net52 VB2 net62 VSS) nmos4
R4 (net51 VSS) resistor
R3 (net43 VSS) resistor
R2 (net35 VSS) resistor
R1 (net29 VSS) resistor
R0 (net23 VSS) resistor
