M5 (VOUT1 VB1 net016 VSS) nmos4
M4 (net04 VB1 net018 VSS) nmos4
M3 (net016 VIN2 IB1 VSS) nmos4
M1 (net018 VIN1 IB1 VSS) nmos4
M9 (net017 net019 VDD VDD) pmos4
M8 (net019 net019 VDD VDD) pmos4
M7 (VOUT1 net04 net017 VDD) pmos4
M6 (net04 net04 net019 VDD) pmos4
