M3 (VDD VIN2 IB1 VSS) nmos4
M2 (IOUT2 VIN2 IB2 VSS) nmos4
M1 (VDD VIN1 IB2 VSS) nmos4
M0 (IOUT1 VIN1 IB1 VSS) nmos4
