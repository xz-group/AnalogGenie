M1 (net023 net07 VSS VSS) nmos4
M2 (net05 net023 VSS VSS) nmos4
M6 (net02 net07 VSS VSS) nmos4
M8 (IB1 net07 VSS VSS) nmos4
M7 (net05 net02 net07 VSS) nmos4
R0 (net07 VSS) resistor
M0 (net023 net07 VDD VDD) pmos4
M5 (IB2 net05 VDD VDD) pmos4
M3 (net02 net05 VDD VDD) pmos4
M4 (net05 net05 VDD VDD) pmos4
