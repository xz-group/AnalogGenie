L3 (VDD VOUT2) inductor
L2 (VOUT1 VDD) inductor
L0 (VOUT3 VDD) inductor
L1 (VDD VOUT4) inductor
C3 (VOUT2 VSS) capacitor
C2 (VOUT1 VSS) capacitor
C1 (VOUT4 VSS) capacitor
C0 (VOUT3 VSS) capacitor
M7 (net43 VOUT1 net32 VSS) nmos4
M6 (VOUT1 VOUT4 net45 VSS) nmos4
M5 (VOUT2 VOUT3 net43 VSS) nmos4
M4 (net45 VOUT2 net32 VSS) nmos4
M3 (VOUT4 VOUT2 net42 VSS) nmos4
M1 (VOUT3 VOUT1 net44 VSS) nmos4
M8 (net32 VB1 VSS VSS) nmos4
M2 (net42 VOUT3 net32 VSS) nmos4
M0 (net44 VOUT4 net32 VSS) nmos4
