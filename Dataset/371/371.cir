M1 (net013 net013 VSS VSS) nmos4
M4 (net015 net013 net018 VSS) nmos4
M0 (net015 net015 net013 VSS) nmos4
R0 (net018 VSS) resistor
M3 (net013 net015 VDD VDD) pmos4
M13 (net015 net015 VDD VDD) pmos4
