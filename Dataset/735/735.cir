M2 (net013 net015 IB1 VSS) nmos4
M3 (net2 VREF1 IB1 VSS) nmos4
M5 (IB2 net2 VDD VDD) pmos4
M4 (net015 net2 VDD VDD) pmos4
M1 (net013 net013 VDD VDD) pmos4
M0 (net2 net013 VDD VDD) pmos4
R0 (net015 VSS) resistor
