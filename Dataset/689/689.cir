M5 (VOUT1 net016 VSS VSS) nmos4
M6 (IB1 IB1 VDD VDD) pmos4
M7 (VOUT1 IB1 VDD VDD) pmos4
C0 (VOUT1 VSS) capacitor
R1 (net016 VIN1) resistor
