MM10 (net27 net12 VSS VSS) nmos4
MM9 (net21 net12 VSS VSS) nmos4
MM8 (net12 net1003 net27 VSS) nmos4
MM7 (VOUT1 net1003 net21 VSS) nmos4
MM3 (net32 net7 net10 VSS) nmos4
MM0 (net26 net8 net10 VSS) nmos4
MM4 (net10 VB2 VSS VSS) nmos4
MM6 (net12 VB3 net26 VDD) pmos4
MM5 (VOUT1 VB3 net32 VDD) pmos4
MM1 (net32 VB1 VDD VDD) pmos4
MM2 (net26 VB1 VDD VDD) pmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
Q1 (VSS VSS net13 0) pnp
Q0 (VSS VSS net7 0) pnp
R2 (VOUT1 net7) resistor
R1 (VOUT1 net8) resistor
R0 (net8 net13) resistor
