M2 (net05 net02 VSS VSS) nmos4
M0 (VOUT1 net02 VSS VSS) nmos4
M3 (net02 net02 VSS VSS) nmos4
R3 (net011 VIN1) resistor
R5 (VDD net013) resistor
C0 (VDD VIN1) capacitor
C2 (VOUT1 VSS) capacitor
C6 (VOUT1 net011) capacitor
M1 (VOUT1 VIN1 VDD VDD) pmos4
M8 (net02 net05 VDD VDD) pmos4
M7 (net05 net05 net013 VDD) pmos4
