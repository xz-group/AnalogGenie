M1 (VOUT1 VIN1 VSS VSS) nmos4
R1 (VDD VOUT1) resistor
R0 (VIN1 VSS) resistor
M2 (VIN1 VB1 VOUT1 VDD) pmos4
