M2 (net9 VIN2 IB1 VSS) nmos4
M3 (VOUT1 VIN1 IB1 VSS) nmos4
M1 (net9 net9 VDD VDD) pmos4
M0 (VOUT1 net9 VDD VDD) pmos4
