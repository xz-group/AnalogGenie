C1 (net7 net1) capacitor
C0 (VSS IIN1) capacitor
M1 (VOUT1 net1 IIN1 VDD) pmos4
M0 (VOUT1 net1 VSS VSS) nmos4
R1 (net1 VOUT1) resistor
R0 (VIN1 net7) resistor
