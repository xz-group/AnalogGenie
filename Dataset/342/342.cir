R3 (net08 net010) resistor
R2 (VOUT1 VSS) resistor
R0 (net010 VIN1) resistor
C3 (VOUT1 net08) capacitor
C0 (VDD net010) capacitor
C2 (VOUT1 VSS) capacitor
M1 (VOUT1 net010 VDD VDD) pmos4
