M1 (VDD net9 VOUT1 VSS) nmos4
M0 (net9 VIN1 VOUT1 VSS) nmos4
R1 (VOUT1 VSS) resistor
R0 (VDD net9) resistor
