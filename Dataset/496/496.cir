M2 (VOUT1 VLO2 VRF2 VSS) nmos4
M0 (VOUT1 VLO1 VRF1 VSS) nmos4
M3 (VOUT2 VLO1 VRF2 VSS) nmos4
M1 (VOUT2 VLO2 VRF1 VSS) nmos4
R3 (VSS VOUT2) resistor
R2 (VSS VOUT1) resistor
