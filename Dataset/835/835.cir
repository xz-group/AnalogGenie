Q3 (net10 net4 VSS 0) npn
Q2 (net4 net4 VSS 0) npn
Q1 (IOUT1 IIN1 net10 0) npn
Q0 (IIN1 IIN1 net4 0) npn
