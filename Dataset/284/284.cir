M3 (VOUT1 VOUT1 IB1 VSS) nmos4
M1 (net013 VIN1 IB1 VSS) nmos4
M9 (VOUT1 net013 VDD VDD) pmos4
M8 (net013 net013 VDD VDD) pmos4
