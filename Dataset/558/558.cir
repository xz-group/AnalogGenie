R0 (VDD VOUT1) resistor
M7 (VOUT1 VB1 IB1 VSS) nmos4
M8 (VDD LOGICB1 IB1 VSS) nmos4
M0 (VDD LOGICB2 IB2 VSS) nmos4
M1 (VOUT1 VB1 IB2 VSS) nmos4
M2 (VDD LOGICA1 IB1 VSS) nmos4
M3 (VDD LOGICA2 IB2 VSS) nmos4
