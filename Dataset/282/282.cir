M3 (VOUT1 VIN2 IB1 VSS) nmos4
M1 (net019 VIN1 IB1 VSS) nmos4
C0 (VOUT1 VSS) capacitor
M9 (VOUT1 net019 VDD VDD) pmos4
M8 (net019 net019 VDD VDD) pmos4
