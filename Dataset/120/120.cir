M2 (VOUT1 VOUT1 net019 VSS) nmos4
M0 (net018 VIN1 net019 VSS) nmos4
M1 (net019 VB1 VSS VSS) nmos4
M4 (VOUT1 net018 VDD VDD) pmos4
M3 (net018 net018 VDD VDD) pmos4
