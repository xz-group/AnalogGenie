M2 (net21 VB1 VDD VDD) pmos4
M1 (VOUT2 VB1 VDD VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M10 (net24 VCM2 VSS VSS) nmos4
M9 (net24 VCM1 VSS VSS) nmos4
M8 (net21 net21 net24 VSS) nmos4
M7 (net14 VOUT2 VSS VSS) nmos4
M6 (net14 VOUT1 VSS VSS) nmos4
M5 (net15 net21 net14 VSS) nmos4
M4 (VOUT2 VIN2 net15 VSS) nmos4
M3 (VOUT1 VIN1 net15 VSS) nmos4
