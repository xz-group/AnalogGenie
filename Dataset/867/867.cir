Q1 (VSS VSS net48 0) pnp
Q0 (VSS VSS net49 0) pnp
M5 (net43 net43 net49 VSS) nmos4
M3 (net45 net43 net48 VSS) nmos4
M1 (net43 net45 VDD VDD) pmos4
M0 (net45 net45 VDD VDD) pmos4
