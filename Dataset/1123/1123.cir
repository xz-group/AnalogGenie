L0 (VDD VOUT1) inductor
L5 (VDD VOUT3) inductor
L4 (VOUT4 VDD) inductor
L1 (VOUT2 VDD) inductor
C7 (VCONT2 VOUT4) capacitor
C6 (VCONT2 VOUT3) capacitor
C1 (VCONT1 VOUT2) capacitor
C0 (VCONT1 VOUT1) capacitor
M7 (VOUT4 VOUT1 IB2 VSS) nmos4
M6 (VOUT3 VOUT2 IB2 VSS) nmos4
M3 (VOUT2 VOUT4 IB1 VSS) nmos4
M2 (VOUT1 VOUT3 IB1 VSS) nmos4
M5 (VOUT4 VOUT3 IB2 VSS) nmos4
M4 (VOUT3 VOUT4 IB2 VSS) nmos4
M1 (VOUT2 VOUT1 IB1 VSS) nmos4
M0 (VOUT1 VOUT2 IB1 VSS) nmos4
