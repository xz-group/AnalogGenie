M5 (net20 net8 net21 VDD) pmos4
M4 (net32 net8 net19 VDD) pmos4
M3 (VOUT1 net21 VDD VDD) pmos4
M2 (net21 net19 VDD VDD) pmos4
M1 (net19 net19 VDD VDD) pmos4
M0 (net9 net9 VDD VDD) pmos4
M11 (VOUT1 net8 VSS VSS) nmos4
M10 (net8 net8 VSS VSS) nmos4
M9 (net18 net8 VSS VSS) nmos4
M8 (net32 VIN1 net18 VSS) nmos4
M7 (net20 VIN2 net18 VSS) nmos4
M6 (net9 net9 net8 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 net20) capacitor
