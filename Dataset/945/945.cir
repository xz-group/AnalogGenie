M2 (IOUT1 net39 VDD VDD) pmos4
M0 (net39 net39 VDD VDD) pmos4
M1 (net34 net39 VDD VDD) pmos4
D0 (net38 VSS) diode
R0 (net37 VSS) resistor
M4 (IIN1 net34 net38 VSS) nmos4
M3 (net34 net34 net37 VSS) nmos4
M6 (net39 IIN1 VSS VSS) nmos4
