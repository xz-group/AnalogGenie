M7 (net24 VLO2 VDD VDD) pmos4
M6 (net10 VLO1 VDD VDD) pmos4
M1 (VOUT2 IB1 VDD VDD) pmos4
M0 (VOUT1 IB1 VDD VDD) pmos4
C1 (VOUT2 VSS) capacitor
C0 (VOUT1 VSS) capacitor
M9 (net24 VLO2 VSS VSS) nmos4
M8 (net10 VLO1 VSS VSS) nmos4
M5 (VOUT2 VRF1 net24 VSS) nmos4
M4 (VOUT1 VRF2 net24 VSS) nmos4
M3 (VOUT2 VRF2 net10 VSS) nmos4
M2 (VOUT1 VRF1 net10 VSS) nmos4
R1 (IB1 VOUT2) resistor
R0 (IB1 VOUT1) resistor
