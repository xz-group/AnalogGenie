M0 (IB2 VB1 IB1 VSS) nmos4
M1 (net012 VIN1 VSS VSS) nmos4
M4 (VOUT1 IB2 net012 VSS) nmos4
R0 (VDD VOUT1) resistor
M3 (IB1 net012 VDD VDD) pmos4
