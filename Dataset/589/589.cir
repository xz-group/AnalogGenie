C0 (net19 VSS) capacitor
R1 (net17 VOUT1) resistor
R0 (net19 VOUT1) resistor
L0 (VDD VOUT1) inductor
M2 (net17 net17 net19 VSS) nmos4
M1 (VOUT1 net19 net23 VSS) nmos4
M0 (net23 VIN1 VSS VSS) nmos4
