C0 (net0111 VOUT1) capacitor
C1 (VOUT1 net0112) capacitor
M11 (net097 IB1 net0125 VSS) nmos4
M12 (IB1 IB1 net0127 VSS) nmos4
M10 (net0127 IB1 VSS VSS) nmos4
M9 (net0125 IB1 VSS VSS) nmos4
M15 (net0112 IB1 net060 VSS) nmos4
M16 (net099 IB1 net059 VSS) nmos4
M8 (net060 IB1 VSS VSS) nmos4
M17 (net059 IB1 VSS VSS) nmos4
M22 (net0111 net0110 net0112 VSS) nmos4
M24 (net8 net8 VSS VSS) nmos4
M25 (net0110 net0110 net8 VSS) nmos4
M27 (VOUT1 net0112 VSS VSS) nmos4
M21 (net0106 IB1 VSS VSS) nmos4
M0 (net0128 net097 VDD VDD) pmos4
M1 (net0126 net097 VDD VDD) pmos4
M4 (net0124 net099 VDD VDD) pmos4
M5 (net0116 net099 VDD VDD) pmos4
M2 (net097 net097 net0128 VDD) pmos4
M3 (net015 net097 net0126 VDD) pmos4
M6 (net099 net056 net0124 VDD) pmos4
M7 (net0111 net056 net0116 VDD) pmos4
M14 (net059 VIN2 net015 VDD) pmos4
M13 (net060 VIN1 net015 VDD) pmos4
M18 (net0112 net0106 net0111 VDD) pmos4
M19 (net0106 net0106 net0107 VDD) pmos4
M20 (net0107 net0107 VDD VDD) pmos4
M23 (net0110 net097 VDD VDD) pmos4
M26 (VOUT1 net0111 VDD VDD) pmos4
R0 (net099 net099) resistor
