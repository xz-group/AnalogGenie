M1 (VOUT2 VIN2 IB1 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
M3 (VOUT2 VOUT2 VDD VDD) pmos4
M2 (VOUT1 VOUT1 VDD VDD) pmos4
