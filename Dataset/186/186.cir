M2 (VOUT1 VB1 VIN1 VSS) nmos4
M1 (VIN1 IB1 VSS VSS) nmos4
M0 (IB1 IB1 VSS VSS) nmos4
C0 (IB1 VSS) capacitor
R0 (VDD VOUT1) resistor
