R0 (VDD VOUT1) resistor
M11 (net47 VIN1 VSS VSS) nmos4
M10 (VOUT1 net43 net47 VSS) nmos4
M9 (net53 net47 IB1 VSS) nmos4
M8 (net50 VB4 IB1 VSS) nmos4
M5 (net43 VB2 net55 VSS) nmos4
M4 (net51 VB2 net54 VSS) nmos4
M7 (net55 net51 VSS VSS) nmos4
M6 (net54 net51 VSS VSS) nmos4
M0 (net50 VB3 VDD VDD) pmos4
M1 (net53 VB3 VDD VDD) pmos4
M3 (net43 VB1 net53 VDD) pmos4
M2 (net51 VB1 net50 VDD) pmos4
