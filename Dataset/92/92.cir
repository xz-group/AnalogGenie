M2 (net017 VIN2 net016 VSS) nmos4
M0 (net014 VIN1 net016 VSS) nmos4
M1 (net016 VB1 VSS VSS) nmos4
M6 (VOUT2 VB2 net017 VSS) nmos4
M5 (VOUT1 VB2 net014 VSS) nmos4
M4 (VOUT2 VOUT2 VDD VDD) pmos4
M3 (VOUT1 VOUT1 VDD VDD) pmos4
R0 (net017 net014) resistor
