R4 (net1 VSS) resistor
R3 (net7 net1) resistor
R0 (net8 net1) resistor
R1 (VDD VOUT1) resistor
R2 (VDD VOUT2) resistor
Q1 (VOUT2 VIN2 net7 0) npn
Q0 (VOUT1 VIN1 net8 0) npn
