M9 (IB2 IB2 net39 VDD) pmos4
M8 (VSS IB2 net30 VDD) pmos4
M7 (VSS IB1 net28 VDD) pmos4
M6 (IB1 IB1 net40 VDD) pmos4
M1 (IOUT1 net17 VDD VDD) pmos4
M0 (net17 net17 VDD VDD) pmos4
M5 (IOUT1 VIN1 net40 VSS) nmos4
M4 (IOUT1 VIN2 net39 VSS) nmos4
M3 (net17 VIN2 net28 VSS) nmos4
M2 (net17 VIN1 net30 VSS) nmos4
