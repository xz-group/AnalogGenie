M3 (net23 net21 net35 VDD) pmos4
M2 (net21 net21 net22 VDD) pmos4
M1 (net35 net22 VDD VDD) pmos4
M0 (net22 net22 VDD VDD) pmos4
M13 (net11 VCLK1 net28 VSS) nmos4
M12 (VOUT1 VCLK1 VIN1 VSS) nmos4
M11 (net28 IB1 VSS VSS) nmos4
M10 (VDD net23 net28 VSS) nmos4
M9 (IB1 IB1 VSS VSS) nmos4
M8 (net19 IB1 VSS VSS) nmos4
M7 (net36 net11 net19 VSS) nmos4
M6 (net37 VSS net19 VSS) nmos4
M5 (net23 VB1 net36 VSS) nmos4
M4 (net21 VB1 net37 VSS) nmos4
C1 (VOUT1 net28) capacitor
C0 (net11 VOUT1) capacitor
