M18 (VSS net100 VOUT1 VDD) pmos4
M17 (net100 net100 VIN2 VDD) pmos4
M16 (net98 VB1 VDD VDD) pmos4
M0 (net111 net111 VDD VDD) pmos4
M11 (net107 VOUT1 IB3 VDD) pmos4
M10 (net114 VIN2 IB3 VDD) pmos4
M5 (VOUT1 net123 VDD VDD) pmos4
M4 (IB1 net111 VDD VDD) pmos4
M3 (VSS IB1 net111 VDD) pmos4
M2 (VSS IB1 net123 VDD) pmos4
M1 (net123 net111 VDD VDD) pmos4
M21 (net100 VIN1 VSS VSS) nmos4
M20 (VDD net98 VOUT1 VSS) nmos4
M19 (net98 net98 VIN2 VSS) nmos4
M15 (VOUT1 net114 VSS VSS) nmos4
M14 (IB4 net107 VSS VSS) nmos4
M13 (net114 net107 VSS VSS) nmos4
M12 (net107 net107 VSS VSS) nmos4
M9 (VDD IB4 net114 VSS) nmos4
M8 (VDD IB4 net107 VSS) nmos4
M7 (net111 VOUT1 IB2 VSS) nmos4
M6 (net123 VIN2 IB2 VSS) nmos4
C1 (VOUT1 net114) capacitor
C0 (net123 VOUT1) capacitor
