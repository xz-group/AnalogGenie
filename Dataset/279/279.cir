M1 (VIN1 net2 VDD VDD) pmos4
M2 (net2 net2 VDD VDD) pmos4
M0 (net2 VIN1 VSS VSS) nmos4
C0 (net2 VSS) capacitor
R0 (VIN1 VSS) resistor
