M8 (IB4 IB4 VSS VSS) nmos4
M7 (IB3 IB3 VSS VSS) nmos4
M4 (IB1 IB4 VSS VSS) nmos4
M1 (IOUT1 IB1 net024 VSS) nmos4
M0 (net024 IIN1 VSS VSS) nmos4
M2 (IIN1 IB2 net025 VSS) nmos4
M3 (net025 IIN1 VSS VSS) nmos4
M5 (IB2 IB3 VSS VSS) nmos4
