MM4 (net28 VOUT1 net12 net22) pmos4
MM3 (net29 net93 net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB2 net25 VDD) pmos4
MM5 (VOUT1 VB2 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 net1001 VSS VSS) nmos4
MM9 (net28 net1001 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (VOUT1 net1003 net28 VSS) nmos4
MM15 (net1003 net1003 net1001 VSS) nmos4
MM13 (net1001 net1001 VSS VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM11 (net023 net024 VB3 VSS) nmos4
MM8 (net025 net010 net023 VSS) nmos4
MM9 (net024 net024 net023 VSS) nmos4
MM7 (net010 net010 net025 VSS) nmos4
MM2 (VB3 VB3 VSS VSS) nmos4
MM0 (net1006 net025 VSS VSS) nmos4
MM10 (net024 net1006 VDD VDD) pmos4
MM4 (net010 net1006 VDD VDD) pmos4
MM3 (VB3 net1006 VDD VDD) pmos4
MM1 (net1006 net1006 VDD VDD) pmos4
M10 (net97 VCLK3 VSS VSS) nmos4
M13 (net94 VCLK2 VSS VSS) nmos4
M11 (net97 VCLK4 VOUT1 VSS) nmos4
M15 (net94 VCLK1 VOUT1 VOUT1) nmos4
M16 (VIN1 VCLK2 net95 VSS) nmos4
M12 (net95 VCLK1 VSS VSS) nmos4
M17 (VIN2 VCLK2 net96 VSS) nmos4
M21 (net92 VCLK2 VSS VSS) nmos4
M20 (net92 VCLK1 VSS VSS) nmos4
M18 (net93 VCLK4 net91 VSS) nmos4
M14 (net96 VCLK1 VSS VSS) nmos4
M19 (net91 VCLK3 VSS VSS) nmos4
C3 (net97 VOUT1) capacitor
C1 (VOUT1 net94) capacitor
C2 (VOUT1 net95) capacitor
C6 (net92 net93) capacitor
C5 (net93 net96) capacitor
C7 (VSS net91) capacitor
