Q1 (net14 VIN1 VSS 0) npn
Q0 (VDD net17 VOUT1 0) npn
R1 (VOUT1 VSS) resistor
Q6 (net14 VB1 VDD 0) pnp
Q4 (VSS net16 VOUT1 0) pnp
Q2 (net17 VB1 VDD 0) pnp
Q3 (VSS net14 net16 0) pnp
D1 (net22 net16) diode
D0 (net17 net22) diode
