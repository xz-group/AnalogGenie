M4 (net09 net012 VSS VSS) nmos4
M1 (net012 net013 VSS VSS) nmos4
R0 (net013 net012) resistor
M13 (net09 net09 VDD VDD) pmos4
M3 (net013 net09 VDD VDD) pmos4
