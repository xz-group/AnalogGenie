M5 (VOUT1 net15 net21 VDD) pmos4
M4 (net27 net15 net16 VDD) pmos4
M3 (net15 net15 VDD VDD) pmos4
M2 (net21 net32 VDD VDD) pmos4
M1 (net16 net32 VDD VDD) pmos4
M0 (net7 net32 VDD VDD) pmos4
M14 (net7 net7 VSS VSS) nmos4
M13 (net15 net7 VSS VSS) nmos4
M12 (net20 net7 VSS VSS) nmos4
M11 (net37 net26 VSS VSS) nmos4
M10 (net26 net26 VSS VSS) nmos4
M9 (VOUT1 net27 net37 VSS) nmos4
M8 (net27 net27 net26 VSS) nmos4
M7 (net21 VIN2 net20 VSS) nmos4
M6 (net16 VIN1 net20 VSS) nmos4
C0 (VOUT1 VSS) capacitor
