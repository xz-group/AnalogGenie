M5 (VOUT1 VB1 net015 VSS) nmos4
M4 (net07 VB1 net018 VSS) nmos4
M3 (net015 VIN2 IB1 VSS) nmos4
M1 (net018 VIN1 IB1 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT1 VIN2) capacitor
M9 (net016 net019 VDD VDD) pmos4
M8 (net019 net019 VDD VDD) pmos4
M7 (VOUT1 net07 net016 VDD) pmos4
M6 (net07 net07 net019 VDD) pmos4
