M4 (net06 net06 VSS VSS) nmos4
M3 (net038 VIN1 net04 VSS) nmos4
M10 (net040 VIN2 net04 VSS) nmos4
M11 (VOUT1 VB1 net038 VSS) nmos4
M1 (VOUT2 VB1 net040 VSS) nmos4
M6 (net04 net06 VSS VSS) nmos4
M5 (net06 net06 VDD VDD) pmos4
M12 (VOUT1 VB2 net037 VDD) pmos4
M13 (VOUT2 VB2 net039 VDD) pmos4
M14 (net037 net06 VDD VDD) pmos4
M15 (net039 net06 VDD VDD) pmos4
