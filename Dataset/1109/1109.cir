M5 (net19 net22 VDD VDD) pmos4
M4 (net7 net13 VDD VDD) pmos4
M3 (net22 net13 net15 VDD) pmos4
M2 (net13 net22 net15 VDD) pmos4
M1 (net15 net14 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
R0 (IB1 net14) resistor
C3 (VOUT2 net19) capacitor
C2 (VOUT1 net7) capacitor
C1 (net15 VSS) capacitor
C0 (net14 VSS) capacitor
D1 (net22 VB1) diode
D0 (net13 VB1) diode
L3 (net7 VSS) inductor
L2 (net19 VSS) inductor
L1 (net22 VSS) inductor
L0 (net13 VSS) inductor
