M1 (net5 net6 VDD VDD) pmos4
M0 (net6 net6 VDD VDD) pmos4
M5 (net4 net4 VSS VSS) nmos4
M4 (net10 net4 net9 VSS) nmos4
M3 (net5 net5 net4 VSS) nmos4
M2 (net6 net5 net10 VSS) nmos4
R0 (net9 VSS) resistor
