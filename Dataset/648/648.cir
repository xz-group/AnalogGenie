M24 (net63 net44 net12 VSS) nmos4
M23 (VOUT1 net44 net12 VSS) nmos4
M22 (net12 IB1 VSS VSS) nmos4
M17 (net8 IB1 VSS VSS) nmos4
M16 (net54 net36 net8 VSS) nmos4
M15 (net53 net35 net8 VSS) nmos4
M14 (net44 net53 net10 VSS) nmos4
M13 (net33 net54 net10 VSS) nmos4
M12 (net10 IB1 VSS VSS) nmos4
M8 (net6 IB1 VSS VSS) nmos4
M7 (net36 net41 net6 VSS) nmos4
M6 (net35 net42 net6 VSS) nmos4
M5 (net42 net63 net4 VSS) nmos4
M2 (net4 IB1 VSS VSS) nmos4
M3 (IB1 IB1 VSS VSS) nmos4
M4 (net41 VOUT1 net4 VSS) nmos4
M25 (VOUT1 net26 VDD VDD) pmos4
M21 (net63 net26 VDD VDD) pmos4
M20 (net33 net31 VDD VDD) pmos4
M19 (net54 net30 VDD VDD) pmos4
M18 (net53 net30 VDD VDD) pmos4
M11 (net44 net31 VDD VDD) pmos4
M10 (net36 net38 VDD VDD) pmos4
M9 (net35 net38 VDD VDD) pmos4
M1 (net42 net39 VDD VDD) pmos4
M0 (net41 net39 VDD VDD) pmos4
