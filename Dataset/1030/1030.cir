M3 (net20 net11 VDD VDD) pmos4
M2 (VOUT1 net17 VDD VDD) pmos4
M1 (net17 net17 VDD VDD) pmos4
M0 (net11 net11 VDD VDD) pmos4
M8 (VOUT1 net20 VSS VSS) nmos4
M7 (net20 net20 VSS VSS) nmos4
M6 (net10 VB1 VSS VSS) nmos4
M5 (net17 VIN1 net10 VSS) nmos4
M4 (net11 VIN2 net10 VSS) nmos4
C0 (VOUT1 VSS) capacitor
