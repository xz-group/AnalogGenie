M0 (IB1 IB1 VDD VDD) pmos4
M3 (VOUT2 VOUT1 net44 VDD) pmos4
M2 (VOUT1 VOUT2 net44 VDD) pmos4
M1 (net44 net41 VDD VDD) pmos4
R0 (IB1 net41) resistor
C3 (VOUT2 net55) capacitor
C2 (VOUT1 net54) capacitor
C1 (net44 VSS) capacitor
C0 (net41 VSS) capacitor
D1 (VOUT2 VB1) diode
D0 (VOUT1 VB1) diode
L5 (net56 VSS) inductor
L4 (net42 VSS) inductor
L1 (VOUT2 net56) inductor
L0 (VOUT1 net42) inductor
M5 (net55 VCONT3 VSS VSS) nmos4
M4 (net54 VCONT1 VSS VSS) nmos4
M6 (net42 VCONT2 net56 VSS) nmos4
