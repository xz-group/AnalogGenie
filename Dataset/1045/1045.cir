M13 (LOGICQ2 net21 VDD VDD) pmos4
M12 (LOGICQ2 LOGICQ1 VDD VDD) pmos4
M9 (net51 VIN2 net13 VDD) pmos4
M8 (net26 VIN1 net13 VDD) pmos4
M7 (LOGICQ1 LOGICQ2 VDD VDD) pmos4
M6 (LOGICQ1 net33 VDD VDD) pmos4
M5 (net33 VCLK1 VDD VDD) pmos4
M4 (net33 net21 VDD VDD) pmos4
M3 (net21 net33 VDD VDD) pmos4
M2 (net21 VCLK1 VDD VDD) pmos4
M1 (net13 IB1 VDD VDD) pmos4
M0 (IB1 IB1 VDD VDD) pmos4
M20 (net58 net21 VSS VSS) nmos4
M19 (net57 net33 VSS VSS) nmos4
M18 (net26 net51 VSS VSS) nmos4
M17 (net51 net26 VSS VSS) nmos4
M16 (net51 VCLK2 net26 VSS) nmos4
M15 (LOGICQ2 LOGICQ1 net58 VSS) nmos4
M14 (LOGICQ1 LOGICQ2 net57 VSS) nmos4
M11 (net33 VCLK1 net26 VSS) nmos4
M10 (net21 VCLK1 net51 VSS) nmos4
