M6 (net034 net010 net030 VSS) nmos4
M4 (net010 net010 net02 VSS) nmos4
M5 (net02 net02 net015 VSS) nmos4
M3 (net030 net02 net016 VSS) nmos4
R0 (net016 net019) resistor
Q1 (VSS VSS net019 0) pnp
Q0 (VSS VSS net015 0) pnp
M9 (net034 net034 net05 VDD) pmos4
M8 (net010 net034 net028 VDD) pmos4
M7 (IB1 net034 net029 VDD) pmos4
M2 (net029 net05 VDD VDD) pmos4
M1 (net028 net05 VDD VDD) pmos4
M0 (net05 net05 VDD VDD) pmos4
