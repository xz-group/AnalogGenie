M0 (net122 VB3 VDD VDD) pmos4
M10 (IREF1 net019 VDD VDD) pmos4
M14 (net115 net019 VDD VDD) pmos4
M3 (net019 VB2 net117 VDD) pmos4
M2 (VSS VB2 net122 VDD) pmos4
M1 (net117 VB3 VDD VDD) pmos4
M9 (net122 net113 VSS VSS) nmos4
M8 (net117 net114 VSS VSS) nmos4
M7 (net129 VSS VSS VSS) nmos4
M6 (net019 VB1 net129 VSS) nmos4
M5 (net130 VSS VSS VSS) nmos4
M4 (VSS VB1 net130 VSS) nmos4
R1 (net115 VSS) resistor
R3 (net115 net114) resistor
R2 (net115 net113) resistor
R0 (net114 net128) resistor
Q1 (VSS VSS net113 0) pnp
Q0 (VSS VSS net128 0) pnp
