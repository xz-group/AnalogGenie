MM7 (VOUT1 net23 net11 net18) pmos4
MM6 (net13 VSS net11 net18) pmos4
MM5 (net11 net1004 VDD VDD) pmos4
MM1 (VOUT1 net17 net20 VSS) nmos4
MM0 (net13 net17 net19 VSS) nmos4
MM9 (net20 net13 VSS VSS) nmos4
MM8 (net19 net13 VSS VSS) nmos4
MM10 (net1004 net1007 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
RR0 (net1007 VSS) resistor
MM2 (VB1 net12 net1007 VSS) nmos4
MM0 (net12 net1007 VSS VSS) nmos4
MM3 (VB1 VB1 VDD VDD) pmos4
MM1 (net12 VB1 VDD VDD) pmos4
M14 (VIN1 VCLK1 net21 VSS) nmos4
M15 (net22 VCLK2 net23 VSS) nmos4
M13 (net22 VCLK1 VSS VSS) nmos4
M12 (net21 VCLK2 VSS VSS) nmos4
C1 (net23 VOUT1) capacitor
C0 (net22 net21) capacitor
