M1 (VOUT1 net5 VSS VSS) nmos4
M0 (net5 VIN1 VSS VSS) nmos4
R1 (VDD VOUT1) resistor
R0 (VDD net5) resistor
