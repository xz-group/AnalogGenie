M19 (VOUT1 net27 net36 VDD) pmos4
M16 (net36 VCONT1 VDD VDD) pmos4
M15 (VOUT2 net32 net36 VDD) pmos4
M14 (net32 VOUT4 net28 VDD) pmos4
M13 (net28 VCONT1 VDD VDD) pmos4
M10 (net27 VOUT3 net28 VDD) pmos4
M9 (VOUT3 net11 net20 VDD) pmos4
M6 (net20 VCONT1 VDD VDD) pmos4
M5 (VOUT4 net16 net20 VDD) pmos4
M2 (net12 VCONT1 VDD VDD) pmos4
M1 (net16 VOUT2 net12 VDD) pmos4
M0 (net11 VOUT1 net12 VDD) pmos4
M18 (VOUT2 VCONT2 VSS VSS) nmos4
M17 (VOUT1 VCONT2 VSS VSS) nmos4
M12 (net27 VCONT2 VSS VSS) nmos4
M11 (net32 VCONT2 VSS VSS) nmos4
M8 (VOUT4 VCONT2 VSS VSS) nmos4
M7 (VOUT3 VCONT2 VSS VSS) nmos4
M4 (net16 VCONT2 VSS VSS) nmos4
M3 (net11 VCONT2 VSS VSS) nmos4
