M0 (net39 VIN1 net38 VSS) nmos4
M3 (IB1 IB1 VSS VSS) nmos4
M2 (net38 IB1 VSS VSS) nmos4
M1 (VOUT1 VIN2 net38 VSS) nmos4
M5 (VOUT1 net39 VDD VDD) pmos4
M4 (net39 net39 VDD VDD) pmos4
