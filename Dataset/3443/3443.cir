MM14 (net025 net012 VDD VDD) pmos4
MM13 (net024 net012 VDD VDD) pmos4
MM3 (VOUT1 VB1 net025 VDD) pmos4
MM2 (net012 VB1 net024 VDD) pmos4
MM7 (net11 VOUT1 net14 net27) pmos4
MM6 (net16 net93 net14 net27) pmos4
MM5 (net14 VB2 VDD VDD) pmos4
MM12 (net29 net11 VSS VSS) nmos4
MM11 (net32 net16 VSS VSS) nmos4
MM10 (net33 net11 VSS VSS) nmos4
MM4 (net26 net16 VSS VSS) nmos4
MM1 (VOUT1 net1003 net29 VSS) nmos4
MM0 (net012 net1003 net32 VSS) nmos4
MM9 (net11 net1003 net33 VSS) nmos4
MM8 (net16 net1003 net26 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB3 VSS VSS) nmos4
MM0 (net010 VB3 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB3 net1006 VDD VDD) pmos4
RR0 (VB3 net010) resistor
M10 (net97 VCLK3 VSS VSS) nmos4
M13 (net94 VCLK2 VSS VSS) nmos4
M11 (net97 VCLK4 VOUT1 VSS) nmos4
M15 (net94 VCLK1 VOUT1 VOUT1) nmos4
M16 (VIN1 VCLK2 net95 VSS) nmos4
M12 (net95 VCLK1 VSS VSS) nmos4
M17 (VIN2 VCLK2 net96 VSS) nmos4
M21 (net92 VCLK2 VSS VSS) nmos4
M20 (net92 VCLK1 VSS VSS) nmos4
M18 (net93 VCLK4 net91 VSS) nmos4
M14 (net96 VCLK1 VSS VSS) nmos4
M19 (net91 VCLK3 VSS VSS) nmos4
C3 (net97 VOUT1) capacitor
C1 (VOUT1 net94) capacitor
C2 (VOUT1 net95) capacitor
C6 (net92 net93) capacitor
C5 (net93 net96) capacitor
C7 (VSS net91) capacitor
