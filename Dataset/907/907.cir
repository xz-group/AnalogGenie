M6 (IB3 VB1 IB2 VDD) pmos4
M1 (IB3 VIN1 IB1 VDD) pmos4
M0 (net11 VIN2 IB1 VDD) pmos4
M5 (VOUT1 IB3 VSS VSS) nmos4
M4 (IB3 net11 VSS VSS) nmos4
M3 (net11 net11 VSS VSS) nmos4
R0 (VDD VOUT1) resistor
C0 (VOUT1 IB2) capacitor
