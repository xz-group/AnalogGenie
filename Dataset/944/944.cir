Q0 (IIN1 net24 VSS 0) npn
R0 (net24 VSS) resistor
M6 (net25 IIN1 VSS VSS) nmos4
M2 (IOUT1 net25 VDD VDD) pmos4
M1 (net24 net25 VDD VDD) pmos4
M0 (net25 net25 VDD VDD) pmos4
