M3 (VOUT1 VOUT1 VDD VDD) pmos4
M2 (net26 VOUT1 VDD VDD) pmos4
M1 (net12 net12 VDD VDD) pmos4
M0 (VOUT2 net12 VDD VDD) pmos4
M8 (net13 VB1 VSS VSS) nmos4
M7 (VOUT1 VIN2 net13 VSS) nmos4
M6 (net12 VIN2 net13 VSS) nmos4
M5 (net26 VIN1 net13 VSS) nmos4
M4 (VOUT2 VIN1 net13 VSS) nmos4
C3 (VOUT1 VSS) capacitor
C2 (VOUT1 VSS) capacitor
C1 (net12 VSS) capacitor
C0 (VOUT2 VSS) capacitor
