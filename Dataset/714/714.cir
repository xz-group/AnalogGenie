M13 (net023 net011 VSS VSS) nmos4
M7 (net022 net011 VSS VSS) nmos4
M1 (net011 VB1 net022 VSS) nmos4
M0 (VOUT1 VB1 net023 VSS) nmos4
M12 (net06 VIN2 IB1 VSS) nmos4
M11 (net02 VIN1 IB1 VSS) nmos4
M16 (net011 VB2 net025 VDD) pmos4
M15 (VOUT1 VB2 net024 VDD) pmos4
M14 (net06 VB2 net026 VDD) pmos4
M10 (net02 VB2 net027 VDD) pmos4
M6 (net025 net06 VDD VDD) pmos4
M5 (net024 net02 VDD VDD) pmos4
M8 (net026 net06 VDD VDD) pmos4
M9 (net027 net02 VDD VDD) pmos4
C0 (VOUT1 VSS) capacitor
