M0 (net20 VB1 VIN1 VSS) nmos4
M1 (VOUT1 VIN1 VSS VSS) nmos4
R2 (VIN1 VSS) resistor
M3 (VOUT1 net20 VDD VDD) pmos4
M2 (net20 net20 VDD VDD) pmos4
