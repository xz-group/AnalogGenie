M8 (net032 net08 net028 VSS) nmos4
M5 (net07 net025 net032 VSS) nmos4
M4 (net031 net08 net023 VSS) nmos4
M3 (net08 net025 net031 VSS) nmos4
Q1 (VSS VSS net023 0) pnp
Q0 (VSS VSS net026 0) pnp
R0 (net028 net026) resistor
R1 (net025 net08) resistor
R2 (net024 net07) resistor
M7 (net024 net07 net029 VDD) pmos4
M13 (net030 net024 VDD VDD) pmos4
M1 (net029 net024 VDD VDD) pmos4
M6 (net025 net07 net030 VDD) pmos4
