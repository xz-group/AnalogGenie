MM3 (VOUT1 VSS net16 VSS) nmos4
MM0 (VB1 net12 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM1 (VOUT1 VB1 VDD VDD) pmos4
MM2 (VB1 VB1 VDD VDD) pmos4
MM8 (net1005 net1005 VSS VSS) nmos4
MM10 (net1005 net1006 VDD VDD) pmos4
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 VDD VDD) pmos4
M12 (VIN1 VCLK1 net11 VSS) nmos4
M13 (net11 VCLK2 net12 VSS) nmos4
C1 (net12 VOUT1) capacitor
C0 (net11 VSS) capacitor
