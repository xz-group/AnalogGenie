M18 (VOUT1 VIN1 VSS VSS) nmos4
M17 (VOUT1 VB1 VDD VDD) pmos4
C0 (net011 VOUT1) capacitor
R0 (VIN1 net011) resistor
