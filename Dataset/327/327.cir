M5 (net032 VIN2 IB2 VSS) nmos4
M4 (VOUT1 VIN2 IB1 VSS) nmos4
M3 (VOUT2 VIN1 IB1 VSS) nmos4
M1 (net035 VIN1 IB2 VSS) nmos4
M7 (net035 net035 VDD VDD) pmos4
M6 (VOUT1 net035 VDD VDD) pmos4
M10 (net032 net032 VDD VDD) pmos4
M11 (VOUT2 net032 VDD VDD) pmos4
C0 (VOUT1 VSS) capacitor
C2 (VOUT2 VSS) capacitor
