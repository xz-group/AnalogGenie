M11 (net024 VIN1 IB1 VSS) nmos4
M10 (net025 VOUT1 IB1 VSS) nmos4
M1 (net022 net013 VSS VSS) nmos4
M3 (net023 net013 VSS VSS) nmos4
M4 (net013 VB1 net022 VSS) nmos4
M5 (VOUT1 VB1 net023 VSS) nmos4
M6 (net013 VB2 net024 VDD) pmos4
M7 (VOUT1 VB2 net025 VDD) pmos4
M8 (net024 VB3 VDD VDD) pmos4
M9 (net025 VB3 VDD VDD) pmos4
