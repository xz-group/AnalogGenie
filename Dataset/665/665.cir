M19 (VOUT1 net18 VSS VSS) nmos4
M18 (net30 net17 VSS VSS) nmos4
M17 (net18 net16 net30 VSS) nmos4
M16 (net16 net15 VSS VSS) nmos4
M15 (net15 net15 VSS VSS) nmos4
M14 (net17 net11 VSS VSS) nmos4
M13 (net11 net11 VSS VSS) nmos4
M12 (net20 net20 VSS VSS) nmos4
M11 (VIN1 VIN1 net20 VSS) nmos4
M10 (net11 VIN1 net12 VDD) pmos4
M9 (VSS VSS net12 VDD) pmos4
M8 (VOUT1 net18 VDD VDD) pmos4
M7 (net15 VB2 net14 VDD) pmos4
M6 (VSS VIN1 net14 VDD) pmos4
M5 (IB1 IB1 VDD VDD) pmos4
M4 (net18 IB1 VDD VDD) pmos4
M3 (net17 IB1 VDD VDD) pmos4
M2 (net16 IB1 VDD VDD) pmos4
M1 (net14 IB1 VDD VDD) pmos4
M0 (net12 IB1 VDD VDD) pmos4
D0 (VSS VIN1) diode
R0 (VB1 VIN1) resistor
