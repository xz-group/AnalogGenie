M2 (VOUT2 net11 VDD VDD) pmos4
M1 (VOUT1 net11 VDD VDD) pmos4
M0 (net11 net11 VDD VDD) pmos4
M8 (VOUT2 VDD net15 VIN2) nmos4
M7 (VOUT1 VDD net15 VIN1) nmos4
M6 (net11 net11 VSS VSS) nmos4
M5 (net15 net11 VSS VSS) nmos4
