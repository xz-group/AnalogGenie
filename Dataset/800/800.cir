M13 (net73 VCLK2 VSS VSS) nmos4
M15 (net73 VCLK1 VOUT1 VOUT1) nmos4
M14 (net79 VCLK2 VOUT1 VSS) nmos4
M16 (VIN1 VCLK1 net68 VSS) nmos4
M9 (net77 net79 IB1 VSS) nmos4
M8 (net83 VSS IB1 VSS) nmos4
M5 (VOUT1 VB2 net85 VSS) nmos4
M4 (net71 VB2 net86 VSS) nmos4
M12 (net68 VCLK2 VSS VSS) nmos4
M7 (net85 net71 VSS VSS) nmos4
M6 (net86 net71 VSS VSS) nmos4
C1 (net79 net73) capacitor
C2 (net79 net68) capacitor
C4 (net79 VOUT1) capacitor
M1 (net77 VB3 VDD VDD) pmos4
M0 (net83 VB3 VDD VDD) pmos4
M3 (VOUT1 VB1 net77 VDD) pmos4
M2 (net71 VB1 net83 VDD) pmos4
