M5 (net032 VIN2 IB1 VSS) nmos4
M3 (net030 VIN1 IB1 VSS) nmos4
M1 (VOUT1 net04 VSS VSS) nmos4
M4 (VOUT2 net04 VSS VSS) nmos4
R3 (VOUT2 net04) resistor
R2 (net04 VOUT1) resistor
R1 (net032 net08) resistor
R0 (net08 net030) resistor
M9 (net032 net08 VDD VDD) pmos4
M8 (net030 net08 VDD VDD) pmos4
M7 (VOUT1 net030 VDD VDD) pmos4
M6 (VOUT2 net032 VDD VDD) pmos4
