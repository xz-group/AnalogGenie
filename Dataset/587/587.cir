R2 (net12 VSS) resistor
R1 (net6 VSS) resistor
R0 (VDD net7) resistor
L2 (net11 net18) inductor
L1 (VDD net11) inductor
L0 (net10 net19) inductor
C5 (net19 VSS) capacitor
C4 (VIN1 net6) capacitor
C3 (VIN1 net7) capacitor
C2 (net12 VSS) capacitor
C1 (net18 net12) capacitor
C0 (net11 VSS) capacitor
M2 (net10 net6 VSS VSS) nmos4
M1 (net11 VB1 net17 VSS) nmos4
M0 (net17 net10 VSS VSS) nmos4
M3 (net10 net7 VDD VDD) pmos4
