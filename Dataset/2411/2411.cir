MM4 (net28 net9 net12 net22) pmos4
MM3 (net29 VREF1 net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB3 net25 VDD) pmos4
MM5 (net9 VB3 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 VB2 VSS VSS) nmos4
MM9 (net28 VB2 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (net9 net1003 net28 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB4 net1006 VDD VDD) pmos4
RR0 (net15 VSS) resistor
MM0 (VB4 VB4 VSS VSS) nmos4
MM2 (net1006 VB4 net15 VSS) nmos4
M7 (VOUT2 net12 VOUT1 VDD) pmos4
M6 (VOUT1 VOUT2 VIN1 VDD) pmos4
M4 (net25 net9 net28 VDD) pmos4
M3 (net28 VB6 VIN1 VDD) pmos4
M1 (net12 net12 net29 VDD) pmos4
M0 (net29 net9 VIN1 VDD) pmos4
M9 (VOUT2 net25 VSS VSS) nmos4
M8 (VOUT2 VB5 VSS VSS) nmos4
M5 (net25 net25 VSS VSS) nmos4
M2 (net12 VB5 VSS VSS) nmos4
