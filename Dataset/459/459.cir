R3 (IB1 IB2) resistor
R2 (IB3 IB4) resistor
R1 (VDD VOUT2) resistor
R0 (VDD VOUT1) resistor
M3 (VOUT2 VIN1 IB2 VSS) nmos4
M2 (VOUT2 VIN4 IB4 VSS) nmos4
M1 (VOUT1 VIN3 IB3 VSS) nmos4
M0 (VOUT1 VIN2 IB1 VSS) nmos4
