M6 (net20 VB1 net21 VDD) pmos4
M5 (net12 VB1 net30 VDD) pmos4
M4 (net21 VIN1 net15 VDD) pmos4
M3 (net30 VIN2 net15 VDD) pmos4
M2 (VOUT1 net28 VDD VDD) pmos4
M1 (net15 net28 VDD VDD) pmos4
M0 (net31 net28 VDD VDD) pmos4
M10 (VOUT1 net20 VSS VSS) nmos4
M9 (net12 net12 VSS VSS) nmos4
M8 (net20 net12 VSS VSS) nmos4
M7 (net31 VB1 VSS VSS) nmos4
C0 (VOUT1 net21) capacitor
