M4 (VOUT2 VIN2 IB1 VSS) nmos4
M3 (VOUT1 VIN1 IB1 VSS) nmos4
M8 (VOUT2 VOUT1 VDD VDD) pmos4
M7 (VOUT1 VOUT2 VDD VDD) pmos4
M6 (VOUT1 VOUT1 VDD VDD) pmos4
M5 (VOUT2 VOUT2 VDD VDD) pmos4
