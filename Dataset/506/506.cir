M0 (net8 VRF1 VSS VSS) nmos4
M2 (VIF2 VLO2 net8 VSS) nmos4
M3 (VIF1 VLO1 net8 VSS) nmos4
R0 (VDD VIF1) resistor
R1 (VDD VIF2) resistor
M1 (VIF1 VB1 VDD VDD) pmos4
M4 (VIF2 VB1 VDD VDD) pmos4
