M26 (VOUT1 net074 VDD VDD) pmos4
M23 (net036 IB1 VDD VDD) pmos4
M20 (net031 net031 VDD VDD) pmos4
M19 (net030 net030 net031 VDD) pmos4
M0 (net081 IB1 VDD VDD) pmos4
M1 (net082 IB1 VDD VDD) pmos4
M2 (IB1 IB1 net081 VDD) pmos4
M3 (net066 IB1 net082 VDD) pmos4
M4 (net085 IB1 VDD VDD) pmos4
M5 (net078 IB1 VDD VDD) pmos4
M18 (net038 net030 net074 VDD) pmos4
M7 (net074 IB1 net078 VDD) pmos4
M6 (net071 IB1 net085 VDD) pmos4
M27 (VOUT1 net038 VSS VSS) nmos4
M25 (net036 net036 net87 VSS) nmos4
M24 (net87 net87 VSS VSS) nmos4
M22 (net074 net036 net038 VSS) nmos4
M21 (net030 net011 VSS VSS) nmos4
M8 (net056 net071 VSS VSS) nmos4
M17 (net055 net071 VSS VSS) nmos4
M16 (net071 net071 net055 VSS) nmos4
M15 (net038 net071 net056 VSS) nmos4
M14 (net078 VIN1 net069 VSS) nmos4
M13 (IB1 VIN2 net069 VSS) nmos4
M9 (net084 net011 VSS VSS) nmos4
M12 (net011 net066 net083 VSS) nmos4
M11 (net069 net066 net084 VSS) nmos4
M10 (net083 net011 VSS VSS) nmos4
C1 (VOUT1 net038) capacitor
C0 (net074 VOUT1) capacitor
R0 (net066 net011) resistor
