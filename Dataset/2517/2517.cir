MM8 (net9 net9 VSS VSS) nmos4
MM7 (net8 net9 VSS VSS) nmos4
MM3 (net20 net38 net16 VSS) nmos4
MM0 (net11 VREF1 net16 VSS) nmos4
MM4 (net16 net1005 VSS VSS) nmos4
MM6 (net9 net11 VIN1 VIN1) pmos4
MM5 (net8 net20 VIN1 VIN1) pmos4
MM1 (net20 net20 VIN1 VIN1) pmos4
MM2 (net11 net11 VIN1 VIN1) pmos4
MM2 (net1005 net1005 VSS VSS) nmos4
MM10 (VB1 net1007 VSS VSS) nmos4
MM1 (net1005 VB1 VIN1 VIN1) pmos4
MM0 (VB1 VB1 VIN1 VIN1) pmos4
MM2 (VB2 net1007 VSS VSS) nmos4
MM0 (net010 net1007 VSS VSS) nmos4
MM3 (VB2 VB2 VIN1 VIN1) pmos4
MM1 (net1007 VB2 VIN1 VIN1) pmos4
RR0 (net1007 net010) resistor
M14 (VOUT1 net36 VIN1 VIN1) pmos4
M11 (net36 net34 VIN1 VIN1) pmos4
M10 (net34 net34 VIN1 VIN1) pmos4
M6 (net26 net26 VIN1 VIN1) pmos4
M5 (net20 net20 VIN1 VIN1) pmos4
M3 (net17 net20 VIN1 VIN1) pmos4
M0 (net11 VB4 VIN1 VIN1) pmos4
M13 (net36 net11 VSS VSS) nmos4
M12 (net34 net8 VSS VSS) nmos4
M9 (net25 VB5 VSS VSS) nmos4
M8 (net20 VB3 net25 VSS) nmos4
M7 (net26 net17 net25 VSS) nmos4
M4 (net17 net8 VSS VSS) nmos4
M2 (net11 net11 VSS VSS) nmos4
M1 (net11 net8 VSS VSS) nmos4
C2 (VOUT1 net38) capacitor
C1 (VOUT1 net8) capacitor
C0 (net8 net17) capacitor
R1 (net38 VSS) resistor
R0 (VOUT1 net38) resistor
