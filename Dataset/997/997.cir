M3 (VOUT1 net25 VDD VDD) pmos4
M2 (net25 net25 VDD VDD) pmos4
M1 (net14 net14 VDD VDD) pmos4
M0 (net11 net14 VDD VDD) pmos4
M9 (VOUT1 net11 VSS VSS) nmos4
M8 (net11 net11 VSS VSS) nmos4
M7 (IB1 IB1 VSS VSS) nmos4
M6 (net21 IB1 VSS VSS) nmos4
M5 (net25 VIN1 net21 VSS) nmos4
M4 (net14 VOUT1 net21 VSS) nmos4
C0 (VOUT1 VSS) capacitor
