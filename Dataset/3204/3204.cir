MM4 (net28 net23 net12 net22) pmos4
MM3 (net29 VSS net12 net22) pmos4
MM0 (net12 VB1 VDD VDD) pmos4
MM6 (net16 VB3 net25 VDD) pmos4
MM5 (VOUT1 VB3 net24 VDD) pmos4
MM2 (net25 net16 VDD VDD) pmos4
MM1 (net24 net16 VDD VDD) pmos4
MM10 (net29 VB2 VSS VSS) nmos4
MM9 (net28 VB2 VSS VSS) nmos4
MM8 (net16 net1003 net29 VSS) nmos4
MM7 (VOUT1 net1003 net28 VSS) nmos4
MM13 (net9 net1003 VSS VSS) nmos4
MM15 (net1003 net1003 net9 VSS) nmos4
MM14 (net1003 net1006 VDD VDD) pmos4
MM2 (net1006 VB4 VSS VSS) nmos4
MM0 (net010 VB4 VSS VSS) nmos4
MM3 (net1006 net1006 VDD VDD) pmos4
MM1 (VB4 net1006 VDD VDD) pmos4
RR0 (VB4 net010) resistor
M14 (VIN1 VCLK1 net21 VSS) nmos4
M15 (net22 VCLK2 net23 VSS) nmos4
M13 (net22 VCLK1 VSS VSS) nmos4
M12 (net21 VCLK2 VSS VSS) nmos4
C1 (net23 VOUT1) capacitor
C0 (net22 net21) capacitor
