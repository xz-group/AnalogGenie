M4 (net5 VCLK1 net6 VDD) pmos4
M6 (LOGICQ1 net6 VDD VDD) pmos4
M3 (net6 net3 VDD VDD) pmos4
M0 (net3 LOGICD1 VDD VDD) pmos4
M7 (LOGICQ1 net5 VSS VSS) nmos4
M5 (net5 net2 VSS VSS) nmos4
M2 (net2 LOGICD1 VSS VSS) nmos4
M1 (net3 VCLK1 net2 VSS) nmos4
C0 (LOGICQ1 VSS) capacitor
