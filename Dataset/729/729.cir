M21 (net032 VDD VSS VSS) nmos4
M17 (VB4 VB4 VSS VSS) nmos4
M16 (net039 VB1 VSS VSS) nmos4
M15 (VB3 VB4 net039 VSS) nmos4
M11 (net9 VB1 VSS VSS) nmos4
M8 (VB2 VB1 VSS VSS) nmos4
M3 (VB1 VB2 IB1 VSS) nmos4
M2 (net5 net9 IB1 VSS) nmos4
M20 (net032 VB3 VDD VDD) pmos4
M19 (VB4 net032 VDD VDD) pmos4
M18 (VB1 net032 VDD VDD) pmos4
M14 (VB3 VB2 net038 VDD) pmos4
M13 (VB4 VB2 net037 VDD) pmos4
M12 (net038 VB3 VDD VDD) pmos4
M10 (net037 VB3 VDD VDD) pmos4
M9 (VB2 VB2 VDD VDD) pmos4
M7 (net9 VB2 net012 net012) pmos4
M1 (net5 net5 VDD VDD) pmos4
M0 (VB1 net5 VDD VDD) pmos4
R0 (VDD net012) resistor
C0 (VB1 VSS) capacitor
