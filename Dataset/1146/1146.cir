M3 (VOUT2 VOUT1 net32 VDD) pmos4
M2 (VOUT1 VOUT2 net32 VDD) pmos4
M1 (net19 net19 VDD VDD) pmos4
M0 (net32 net19 VDD VDD) pmos4
L0 (VOUT1 VOUT2) inductor
M19 (IB1 IB1 VSS VSS) nmos4
M18 (net19 IB1 VSS VSS) nmos4
M17 (VOUT2 VOUT1 VSS VSS) nmos4
M16 (VOUT1 VOUT2 VSS VSS) nmos4
M15 (VCONT6 VOUT1 VCONT6 VSS) nmos4
M14 (VCONT6 VOUT2 VCONT6 VSS) nmos4
M13 (VCONT5 VOUT2 VCONT5 VSS) nmos4
M12 (VCONT5 VOUT1 VCONT5 VSS) nmos4
M11 (VCONT4 VOUT1 VCONT4 VSS) nmos4
M10 (VCONT4 VOUT2 VCONT4 VSS) nmos4
M9 (VCONT3 VOUT2 VCONT3 VSS) nmos4
M8 (VCONT3 VOUT1 VCONT3 VSS) nmos4
M7 (VOUT2 VCONT2 VOUT2 VSS) nmos4
M6 (VOUT1 VCONT2 VOUT1 VSS) nmos4
M5 (VCONT1 VOUT2 VCONT1 VSS) nmos4
M4 (VCONT1 VOUT1 VCONT1 VSS) nmos4
