R5 (net9 VSS) resistor
R4 (net7 VSS) resistor
R3 (net9 net7) resistor
R2 (VOUT1 VDD) resistor
R1 (VOUT2 VOUT1) resistor
R0 (VDD VOUT2) resistor
Q1 (VOUT1 VIN2 net9 0) npn
Q0 (VOUT2 VIN1 net7 0) npn
