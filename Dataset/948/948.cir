M9 (VREF1 net42 VDD VDD) pmos4
M8 (VREF1 net35 VDD VDD) pmos4
M7 (net28 net35 VDD VDD) pmos4
M6 (net26 net42 VDD VDD) pmos4
M4 (net38 net35 VDD VDD) pmos4
M0 (net41 net42 VDD VDD) pmos4
M1 (net42 net42 VDD VDD) pmos4
M3 (net40 net41 net41 VDD) pmos4
M2 (net39 net41 net42 VDD) pmos4
D1 (net40 VSS) diode
D0 (net37 VSS) diode
R2 (VREF1 VSS) resistor
R1 (net28 VSS) resistor
R0 (net39 net37) resistor
M5 (net38 net26 VSS VSS) nmos4
Q0 (net26 net28 VSS 0) npn
