M5 (VOUT1 VB1 net020 VSS) nmos4
M4 (net017 VB1 net022 VSS) nmos4
M3 (net020 VOUT1 IB1 VSS) nmos4
M1 (net022 VIN1 IB1 VSS) nmos4
M9 (net021 net019 VDD VDD) pmos4
M8 (net019 net019 VDD VDD) pmos4
M7 (VOUT1 net017 net021 VDD) pmos4
M6 (net017 net017 net019 VDD) pmos4
