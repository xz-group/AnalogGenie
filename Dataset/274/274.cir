M0 (net5 VIN1 net1 VSS) nmos4
R2 (VOUT1 VSS) resistor
R1 (net1 VSS) resistor
R0 (net1 VOUT1) resistor
M2 (VOUT1 net5 VDD VDD) pmos4
M1 (net5 VB1 VDD VDD) pmos4
