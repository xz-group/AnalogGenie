M5 (net032 VIN2 IB1 VSS) nmos4
M3 (net030 VIN1 IB1 VSS) nmos4
M1 (net02 net02 VSS VSS) nmos4
M4 (VOUT1 net02 VSS VSS) nmos4
M9 (net032 VB1 VDD VDD) pmos4
M8 (net030 VB1 VDD VDD) pmos4
M7 (net02 net030 VDD VDD) pmos4
M6 (VOUT1 net032 VDD VDD) pmos4
