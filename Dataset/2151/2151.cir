MM9 (VOUT1 net12 VSS VSS) nmos4
MM8 (net12 net12 VSS VSS) nmos4
MM7 (VOUT1 VIN2 net10 net14) pmos4
MM6 (net12 VIN1 net10 net14) pmos4
MM5 (net10 net1004 VDD VDD) pmos4
MM0 (net1004 VB1 VSS VSS) nmos4
MM8 (VB1 VB1 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM10 (VB1 net1006 VDD VDD) pmos4
RR0 (VDD net6) resistor
RR1 (net1006 VSS) resistor
MM2 (net1006 net1006 net6 VDD) pmos4
