M8 (VSS VOUT1 IB2 VDD) pmos4
M7 (net17 VCM1 IB2 VDD) pmos4
M6 (net17 VCM1 IB1 VDD) pmos4
M5 (VSS VOUT2 IB1 VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M1 (VOUT2 VB1 VDD VDD) pmos4
M9 (net17 net17 VSS VSS) nmos4
M3 (VOUT2 VIN2 net9 VSS) nmos4
M2 (VOUT1 VIN1 net9 VSS) nmos4
M4 (net9 net17 VSS VSS) nmos4
