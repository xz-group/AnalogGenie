M8 (IB1 IB1 VSS VSS) nmos4
M7 (net058 VIN1 net28 VSS) nmos4
M10 (net049 VOUT1 VSS VSS) nmos4
M11 (net049 VOUT2 VSS VSS) nmos4
M6 (net053 VIN2 net28 VSS) nmos4
M12 (net28 IB1 net049 VSS) nmos4
M5 (VOUT2 VB1 net063 VSS) nmos4
M4 (VOUT1 VB1 net064 VSS) nmos4
M3 (net063 VB3 VSS VSS) nmos4
M1 (net064 VB3 VSS VSS) nmos4
M15 (net043 IB1 net066 VSS) nmos4
M16 (net066 VREF1 VSS VSS) nmos4
M19 (net047 VIN1 net043 VSS) nmos4
M20 (net047 VIN2 net043 VSS) nmos4
M18 (net047 net047 VDD VDD) pmos4
M17 (net053 net047 VDD VDD) pmos4
M14 (net058 net047 VDD VDD) pmos4
M13 (VOUT2 VB2 net053 VDD) pmos4
M9 (VOUT1 VB2 net058 VDD) pmos4
