M5 (VOUT1 net13 net32 VDD) pmos4
M4 (net31 net13 net33 VDD) pmos4
M3 (net13 net13 net14 VDD) pmos4
M2 (net32 net14 VDD VDD) pmos4
M1 (net33 net14 VDD VDD) pmos4
M0 (net14 net14 VDD VDD) pmos4
M11 (net13 net13 VSS VSS) nmos4
M10 (net21 net13 VSS VSS) nmos4
M9 (net29 VIN1 net21 VSS) nmos4
M8 (net30 VIN2 net21 VSS) nmos4
M7 (VOUT1 VB1 net30 VSS) nmos4
M6 (net31 VB1 net29 VSS) nmos4
