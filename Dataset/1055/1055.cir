M1 (net69 VCLK2 VSS VSS) nmos4
M6 (VOUT1 VCLK2 VSS VSS) nmos4
M5 (VOUT1 VOUT2 VSS VSS) nmos4
M4 (VOUT2 VOUT1 VSS VSS) nmos4
M3 (VOUT2 VCLK2 VSS VSS) nmos4
M10 (net60 VIN1 net56 VSS) nmos4
M9 (net63 VIN2 net56 VSS) nmos4
M11 (net56 VCLK1 net69 net69) nmos4
M14 (VOUT1 net60 net68 VDD) pmos4
M13 (VOUT2 net63 net67 VDD) pmos4
M12 (net68 VOUT2 VDD VDD) pmos4
M0 (net67 VOUT1 VDD VDD) pmos4
M8 (net60 VCLK1 VDD VDD) pmos4
M7 (net63 VCLK1 VDD VDD) pmos4
C0 (net69 VSS) capacitor
