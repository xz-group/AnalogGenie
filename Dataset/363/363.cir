M5 (VOUT2 VB1 net020 VSS) nmos4
M4 (VOUT1 VB1 net021 VSS) nmos4
M3 (net020 VIN2 net04 VSS) nmos4
M1 (net021 VIN1 net04 VSS) nmos4
M0 (net04 VB4 VSS VSS) nmos4
M9 (net017 VB3 VDD VDD) pmos4
M8 (net015 VB3 VDD VDD) pmos4
M7 (VOUT2 VB2 net017 net017) pmos4
M6 (VOUT1 VB2 net015 net015) pmos4
