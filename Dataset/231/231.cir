R0 (VOUT1 VDD) resistor
C2 (net08 VSS) capacitor
C1 (VSS net08) capacitor
M0 (VIN1 net08 VSS VSS) nmos4
M1 (VOUT1 VB1 VIN1 VSS) nmos4
