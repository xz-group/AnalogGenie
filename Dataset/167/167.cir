M3 (net8 VB1 VDD VDD) pmos4
M2 (VOUT1 VB1 VDD VDD) pmos4
M1 (net8 VIN1 VSS VSS) nmos4
M0 (VOUT1 net8 VSS VSS) nmos4
C1 (VOUT1 VSS) capacitor
C1 (net8 VSS) capacitor
