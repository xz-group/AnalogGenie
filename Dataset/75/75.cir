M2 (VOUT1 net14 VDD VDD) pmos4
M3 (VOUT2 net14 VDD VDD) pmos4
M1 (VOUT2 VIN2 IB1 VSS) nmos4
M0 (VOUT1 VIN1 IB1 VSS) nmos4
R1 (VOUT1 net14) resistor
R0 (net14 VOUT2) resistor
