M3 (VOUT1 VLO1 VBB2 VSS) nmos4
M2 (VOUT1 VLO2 VBB1 VSS) nmos4
M1 (VOUT2 VLO1 VBB1 VSS) nmos4
M0 (VOUT2 VLO2 VBB2 VSS) nmos4
R1 (VOUT1 VOUT2) resistor
L1 (VOUT1 VOUT2) inductor
