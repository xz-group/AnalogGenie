M2 (VOUT2 VOUT1 net16 VDD) pmos4
M1 (VOUT1 VOUT2 net16 VDD) pmos4
M0 (net16 VLATCH2 VDD VDD) pmos4
M7 (net15 VLATCH1 VSS VSS) nmos4
M6 (VOUT2 VOUT1 net15 VSS) nmos4
M5 (VOUT1 VOUT2 net15 VSS) nmos4
M4 (VIN1 VLATCH2 VOUT2 VSS) nmos4
M3 (VREF1 VLATCH2 VOUT1 VSS) nmos4
