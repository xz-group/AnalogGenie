M7 (net26 net12 net23 VDD) pmos4
M6 (net19 VCM1 net23 VDD) pmos4
M5 (net23 VB2 VDD VDD) pmos4
M1 (VOUT2 VB1 VDD VDD) pmos4
M0 (VOUT1 VB1 VDD VDD) pmos4
M9 (net26 net26 VSS VSS) nmos4
M8 (net19 net19 VSS VSS) nmos4
M4 (net15 net19 VSS VSS) nmos4
M3 (VOUT2 VIN2 net15 VSS) nmos4
M2 (VOUT1 VIN1 net15 VSS) nmos4
R1 (net12 VOUT2) resistor
R0 (VOUT1 net12) resistor
