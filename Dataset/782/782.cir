Q7 (IB2 VB1 net04 0) npn
Q6 (IB1 VB1 net019 0) npn
Q5 (net24 IB1 net06 0) npn
Q4 (VOUT1 net7 net24 0) npn
Q3 (net25 IB2 net06 0) npn
Q2 (VOUT2 net7 net25 0) npn
Q1 (net17 net17 net06 0) npn
Q0 (net7 net7 net17 0) npn
M3 (IB3 IB3 VDD VDD) pmos4
M2 (VOUT1 IB3 VDD VDD) pmos4
M1 (VOUT2 IB3 VDD VDD) pmos4
M0 (net7 IB3 VDD VDD) pmos4
M11 (net019 VIN4 IB1 IB1) nmos4
M10 (net019 VIN2 IB1 IB1) nmos4
M9 (net04 VIN1 IB1 IB1) nmos4
M8 (net04 VIN3 IB1 IB1) nmos4
M7 (net033 VCONT1 IB2 VSS) nmos4
M6 (net036 VCONT1 IB1 VSS) nmos4
M5 (net06 VCM1 VSS VSS) nmos4
C1 (VOUT1 net033) capacitor
C0 (VOUT2 net036) capacitor
