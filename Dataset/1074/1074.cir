M16 (VDD net65 net95 VDD) nmos4
M15 (VDD net95 net65 VDD) nmos4
M5 (net90 net86 VSS VSS) nmos4
M4 (net79 net64 VSS VSS) nmos4
M9 (VOUT1 net64 VSS VSS) nmos4
M8 (VOUT2 net86 VSS VSS) nmos4
M7 (VOUT2 VOUT1 VSS VSS) nmos4
M6 (VOUT1 VOUT2 VSS VSS) nmos4
M13 (net86 VIN2 net83 VSS) nmos4
M12 (net64 VIN1 net83 VSS) nmos4
M14 (net83 VCLK1 VSS VSS) nmos4
C2 (net65 VSS) capacitor
C1 (net95 VCLK2) capacitor
C0 (net65 VCLK1) capacitor
M1 (net90 net86 net65 net65) pmos4
M0 (net79 net64 net65 net65) pmos4
M3 (VOUT2 VOUT1 net90 net65) pmos4
M2 (VOUT1 VOUT2 net79 net65) pmos4
M11 (net86 VCLK1 VDD VDD) pmos4
M10 (net64 VCLK1 VDD VDD) pmos4
