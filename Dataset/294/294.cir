M5 (VOUT2 VB1 net018 VSS) nmos4
M4 (VOUT1 VB1 net022 VSS) nmos4
M3 (net018 VB4 VSS VSS) nmos4
M1 (net022 VB4 VSS VSS) nmos4
M0 (net022 VIN1 IB1 VDD) pmos4
M2 (net018 VIN2 IB1 VDD) pmos4
M9 (net021 VB3 VDD VDD) pmos4
M8 (net023 VB3 VDD VDD) pmos4
M7 (VOUT2 VB2 net021 VDD) pmos4
M6 (VOUT1 VB2 net023 VDD) pmos4
