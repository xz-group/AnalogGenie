M0 (net7 net8 VDD VDD) pmos4
M1 (net8 net7 VSS VSS) nmos4
L0 (net7 net8) inductor
C0 (net7 net8) capacitor
