M40 (net199 VB8 net191 VDD) pmos4
M39 (net224 VB8 net189 VDD) pmos4
M38 (net191 VB7 VDD VDD) pmos4
M37 (net189 VB7 net246 net246) pmos4
M26 (net216 VB5 net213 VDD) pmos4
M25 (net234 VB5 net206 VDD) pmos4
M24 (net213 VB4 VDD VDD) pmos4
M23 (net206 VB4 VDD VDD) pmos4
M14 (net242 VB2 net215 VDD) pmos4
M13 (net205 VB2 net207 VDD) pmos4
M12 (net215 VB1 VDD VDD) pmos4
M9 (net207 VB1 VDD VDD) pmos4
M6 (VOUT1 net242 net231 VDD) pmos4
M5 (VOUT2 net205 net229 VDD) pmos4
M4 (net231 VB9 VDD VDD) pmos4
M3 (net229 VB9 VDD VDD) pmos4
M45 (net224 VB10 net247 VSS) nmos4
M44 (net247 net224 VSS VSS) nmos4
M43 (net243 net224 VSS VSS) nmos4
M42 (net199 VB10 net248 VSS) nmos4
M41 (net248 net199 VSS VSS) nmos4
M36 (net194 VB9 VSS VSS) nmos4
M35 (net231 VIN2 net194 VSS) nmos4
M2 (net191 VIN2 net194 VSS) nmos4
M1 (net229 VIN1 net194 VSS) nmos4
M0 (net189 VIN1 net194 VSS) nmos4
M34 (net216 VB6 VSS VSS) nmos4
M33 (net212 VB6 VSS VSS) nmos4
M32 (net210 VB6 VSS VSS) nmos4
M31 (net234 VB6 VSS VSS) nmos4
M30 (net213 net243 net212 VSS) nmos4
M29 (net206 VSS net212 VSS) nmos4
M28 (net213 VSS net210 VSS) nmos4
M27 (net206 net201 net210 VSS) nmos4
M22 (net242 VB3 VSS VSS) nmos4
M21 (net214 VB3 VSS VSS) nmos4
M20 (net211 VB3 VSS VSS) nmos4
M19 (net205 VB3 VSS VSS) nmos4
M18 (net215 net231 net214 VSS) nmos4
M17 (net207 VSS net214 VSS) nmos4
M16 (net215 VSS net211 VSS) nmos4
M15 (net207 net229 net211 VSS) nmos4
M11 (net201 net199 VSS VSS) nmos4
M8 (VOUT1 net216 net243 VSS) nmos4
M7 (VOUT2 net234 net201 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (VOUT2 VSS) capacitor
