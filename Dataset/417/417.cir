R0 (VDD VOUT1) resistor
C1 (VOUT1 IB1) capacitor
C0 (VDD VOUT1) capacitor
M0 (VOUT1 VB1 IB1 VSS) nmos4
L0 (VDD VOUT1) inductor
