M3 (net028 net02 VDD VDD) pmos4
M2 (net018 net08 VDD VDD) pmos4
M1 (net02 net02 net028 VDD) pmos4
M0 (net08 net02 net018 VDD) pmos4
M9 (net029 net08 VDD VDD) pmos4
M6 (IOUT1 net02 net030 VDD) pmos4
M7 (IOUT2 net02 net029 VDD) pmos4
M8 (net030 net08 VDD VDD) pmos4
R1 (net08 VSS) resistor
R0 (net02 VSS) resistor
