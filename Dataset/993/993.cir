M21 (VSS net36 VOUT1 VDD) pmos4
M17 (VSS net47 net37 VDD) pmos4
M8 (net30 net24 net58 VDD) pmos4
M7 (net42 net24 net59 VDD) pmos4
M6 (net58 net42 VDD VDD) pmos4
M5 (net59 net42 VDD VDD) pmos4
M4 (net40 net17 net61 VDD) pmos4
M3 (net47 net17 net60 VDD) pmos4
M2 (net37 net40 VDD VDD) pmos4
M1 (net60 net40 VDD VDD) pmos4
M0 (net61 net40 VDD VDD) pmos4
R2 (net30 net44) resistor
R1 (net42 net24) resistor
R0 (net40 net17) resistor
M20 (VDD net37 VOUT1 VSS) nmos4
M19 (net36 net44 VSS VSS) nmos4
M18 (VDD net47 net36 VSS) nmos4
M16 (net54 net44 VSS VSS) nmos4
M15 (net55 net44 VSS VSS) nmos4
M14 (net44 net30 net55 VSS) nmos4
M13 (net47 net30 net54 VSS) nmos4
M12 (IB1 IB1 VSS VSS) nmos4
M11 (net19 IB1 VSS VSS) nmos4
M10 (net24 VIN2 net19 VSS) nmos4
M9 (net17 VIN1 net19 VSS) nmos4
C1 (VOUT1 VSS) capacitor
C0 (net47 VSS) capacitor
