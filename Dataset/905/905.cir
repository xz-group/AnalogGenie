M2 (VOUT1 net8 VDD VDD) pmos4
M1 (net13 net8 VDD VDD) pmos4
M0 (net8 net8 VDD VDD) pmos4
M5 (net13 VIN1 VSS VSS) nmos4
M4 (VOUT1 net13 VSS VSS) nmos4
M3 (VOUT1 VCONT1 net13 VSS) nmos4
R0 (net8 VSS) resistor
