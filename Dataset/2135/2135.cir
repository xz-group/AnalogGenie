MM9 (VOUT1 net12 VSS VSS) nmos4
MM8 (net12 net12 VSS VSS) nmos4
MM7 (VOUT1 VIN2 net10 net14) pmos4
MM6 (net12 VIN1 net10 net14) pmos4
MM5 (net10 net1004 VDD VDD) pmos4
MM4 (net1004 VB1 VSS VSS) nmos4
MM2 (VB1 VB1 VSS VSS) nmos4
MM10 (neta net1007 VSS VSS) nmos4
MM3 (net1004 net1004 VDD VDD) pmos4
MM1 (VB1 neta VDD VDD) pmos4
MM0 (neta neta VDD VDD) pmos4
RR1 (net1007 net7) resistor
RR0 (VDD net7) resistor
RRF (VDD net1007) resistor
MM1 (net7 net1007 VSS VSS) nmos4
MM0 (net1007 net1007 VSS VSS) nmos4
